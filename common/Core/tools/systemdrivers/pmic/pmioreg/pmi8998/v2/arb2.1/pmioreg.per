      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_NUM                                 = "
    tree.end
    tree "IBB_TRIM_CTL1"
      sgroup "IBB_TRIM_CTL1 (at 0x1dcf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ERR_AMP_OFFSET_TRIM                      = "
    tree.end
    tree "IBB_TRIM_CTL2"
      sgroup "IBB_TRIM_CTL2 (at 0x1dcf2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_BIAS_GM                             = "
    tree.end
    tree "IBB_TRIM_CTL3"
      sgroup "IBB_TRIM_CTL3 (at 0x1dcf3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_PREAMP_OFFSET                       = "
    tree.end
    tree "IBB_TRIM_CTL4"
      sgroup "IBB_TRIM_CTL4 (at 0x1dcf4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_INZERO_OFFSET                       = "
    tree.end
    tree "IBB_TRIM_CTL5"
      sgroup "IBB_TRIM_CTL5 (at 0x1dcf5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_REF_DAC_BUFF                        = "
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IRQ_STATUS                               = " "0 (NO_INT_CLOCK_REQ),1 (INT_CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_I2C_INTR_STATUS1"
      sgroup "INT_I2C_INTR_STATUS1 (at 0x550)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QNOVO                                    = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCHG8998_DC                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCHG8998_USB                             = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCHG8998_BATIF                           = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SCHG8998_OTG                             = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SCHG8998_CHGR                            = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PON                                      = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI                                     = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_I2C_INTR_STATUS2"
      sgroup "INT_I2C_INTR_STATUS2 (at 0x551)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_LMH                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FG_BCL                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_BATT_INFO                             = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FG_BATT_SOC                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TEMP_ALARM                               = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSI                                      = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB_PD_PHY                               = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SCHG8998_MISC                            = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_I2C_INTR_STATUS3"
      sgroup "INT_I2C_INTR_STATUS3 (at 0x552)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO01                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PBS_CLIENT3                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PBS_CLIENT2                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PBS_CLIENT1                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_CLIENT0                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_DIST                                 = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FG_ADC_RR                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_MEM_IF                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_I2C_INTR_STATUS4"
      sgroup "INT_I2C_INTR_STATUS4 (at 0x553)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO09                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GPIO08                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   GPIO07                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GPIO06                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GPIO05                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GPIO04                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPIO03                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO02                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_I2C_INTR_STATUS5"
      sgroup "INT_I2C_INTR_STATUS5 (at 0x554)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LPG_CHAN1                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BOB_MONITORING                           = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BOB_CONFIG                               = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GPIO14                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GPIO13                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GPIO12                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPIO11                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO10                                   = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_I2C_INTR_STATUS6"
      sgroup "INT_I2C_INTR_STATUS6 (at 0x555)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MVFLASH1                                 = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRI_LED                                  = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HAPTICS                                  = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LPG_CHAN6                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LPG_CHAN5                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LPG_CHAN4                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LPG_CHAN3                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_CHAN2                                = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_I2C_INTR_STATUS7"
      sgroup "INT_I2C_INTR_STATUS7 (at 0x556)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LAB                                      = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBB                                      = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WLED1_CTRL                               = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LAB"
  tree "LAB"
    tree "LAB_REVISION1"
      sgroup "LAB_REVISION1 (at 0x1de00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LAB_REVISION2"
      sgroup "LAB_REVISION2 (at 0x1de01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LAB_REVISION3"
      sgroup "LAB_REVISION3 (at 0x1de02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LAB_REVISION4"
      sgroup "LAB_REVISION4 (at 0x1de03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LAB_PERPH_TYPE"
      sgroup "LAB_PERPH_TYPE (at 0x1de04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LAB_PERPH_SUBTYPE"
      sgroup "LAB_PERPH_SUBTYPE (at 0x1de05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LAB_STATUS1"
      sgroup "LAB_STATUS1 (at 0x1de08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_NOTOK),1 (VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SC_DETECT                                = " "0 (MODULE_NO_SC_FAULT),1 (MODULE_SHORT_CIRCUIT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LAB_STATUS                               = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "LAB_INT_RT_STS"
      sgroup "LAB_INT_RT_STS (at 0x1de10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_RT_STS                           = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "LAB_INT_SET_TYPE"
      sgroup "LAB_INT_SET_TYPE (at 0x1de11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LAB_INT_POLARITY_HIGH"
      sgroup "LAB_INT_POLARITY_HIGH (at 0x1de12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LAB_INT_POLARITY_LOW"
      sgroup "LAB_INT_POLARITY_LOW (at 0x1de13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LAB_INT_LATCHED_CLR"
      sgroup "LAB_INT_LATCHED_CLR (at 0x1de14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LAB_INT_EN_SET"
      sgroup "LAB_INT_EN_SET (at 0x1de15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LAB_INT_EN_CLR"
      sgroup "LAB_INT_EN_CLR (at 0x1de16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LAB_INT_LATCHED_STS"
      sgroup "LAB_INT_LATCHED_STS (at 0x1de18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LAB_INT_PENDING_STS"
      sgroup "LAB_INT_PENDING_STS (at 0x1de19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LAB_INT_MID_SEL"
      sgroup "LAB_INT_MID_SEL (at 0x1de1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LAB_INT_PRIORITY"
      sgroup "LAB_INT_PRIORITY (at 0x1de1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LAB_OUTPUT_VOLTAGE"
      sgroup "LAB_OUTPUT_VOLTAGE (at 0x1de41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERRIDE_OUTPUT_VOLTAGE                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "LAB_RING_SUPPRESSION_CTL"
      sgroup "LAB_RING_SUPPRESSION_CTL (at 0x1de42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RING_SUPPRESSION                  = " "0, 1"
    tree.end
    tree "LAB_PWM_MODE_SEL"
      sgroup "LAB_PWM_MODE_SEL (at 0x1de43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PEAK_VALLEY_SEL                          = " "0 (VALLEY_CUR_MODE),1 (PEAK_CUR_MODE)"
    tree.end
    tree "LAB_LCD_AMOLED_SEL"
      sgroup "LAB_LCD_AMOLED_SEL (at 0x1de44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LCD_AMOLED_SELECT                        = " "0 (LCD_MODE),1 (AMOLED_MODE)"
    tree.end
    tree "LAB_MODULE_RDY"
      sgroup "LAB_MODULE_RDY (at 0x1de45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_RDY                               = " "0 (LAB_NOT_RDY),1 (LAB_RDY)"
    tree.end
    tree "LAB_ENABLE_CTL"
      sgroup "LAB_ENABLE_CTL (at 0x1de46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_EN                                = " "0 (MODULE_DIS),1 (MODULE_EN)"
    tree.end
    tree "LAB_PD_CTL"
      sgroup "LAB_PD_CTL (at 0x1de47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PULLDOWN                             = " "0 (EN_PD),1 (DIS_PD)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PD_STRENGTH                              = " "0 (PD_WEAK),1 (PD_STRONG)"
    tree.end
    tree "LAB_CLK_DIV"
      sgroup "LAB_CLK_DIV (at 0x1de48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "LAB_IBB_EN_RDY"
      sgroup "LAB_IBB_EN_RDY (at 0x1de49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IBB_EN_RDY                               = " "0 (IBB_EN_NOT_RDY),1 (IBB_EN_RDY)"
    tree.end
    tree "LAB_CURRENT_LIMIT"
      sgroup "LAB_CURRENT_LIMIT (at 0x1de4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OVERRIDE_CURRENT_MAX                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SET_CURRENT_MAX                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LAB_CURRENT_SENSE"
      sgroup "LAB_CURRENT_SENSE (at 0x1de4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   IPSENSE_GAIN                             = " "0 (X0P75),1 (X1),2 (X1P3),3 (X2P1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IART_SEL                                 = " "0 (X0UA),1 (X4UA),2 (X8UA),3 (X12UA)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ISENSE_TAP                               = " "0 (reserved),1 (X0P9),2 (X1),3 (X1P1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ISENSE_GAIN                              = " "0 (X0P5),1 (X1),2 (X1P5),3 (X2)"
    tree.end
    tree "LAB_LOOP_COMP_CTL"
      sgroup "LAB_LOOP_COMP_CTL (at 0x1de4d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LOOP_COMP_CAP                            = " "0 (COMP_CAP_16PF),1 (COMP_CAP_32PF),2 (COMP_CAP_48PF),3 (COMP_CAP_64PF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOOP_COMP_RES                            = " "0 (COMP_RES_100K),1 (COMP_RES_200K),2 (COMP_RES_500K),3 (COMP_RES_600K)"
    tree.end
    tree "LAB_SLOPE_COMP_CURRENT"
      sgroup "LAB_SLOPE_COMP_CURRENT (at 0x1de4e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   SLOPE_COMP_CURRENT                       = " "0 (ADAPTIVE_SLP_1X),1 (ADAPTIVE_SLP_1P4X),2 (ADAPTIVE_SLP_1P8X),3 (ADAPTIVE_SLP_2P2X),4 (X2INTEG_SLP_1X),5 (X2INTEG_SLP_SLP_1P2X),6 (X2INTEG_SLP_1P5X),7 (X2INTEG_SLP_2X)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLOPE_COMP_DOUBLER                       = " "0 (DO_NOT_DOUBLE),1 (DOUBLE)"
    tree.end
    tree "LAB_IP_ZERO_DETECTOR"
      sgroup "LAB_IP_ZERO_DETECTOR (at 0x1de4f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de4f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VOLTAGE_OFFSET                           = " "0 (VOFF_0MV),1 (VOFF_1P5MV),2 (VOFF_3MV),3 (VOFF_4P5MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_DETECT_ON                             = " "0 (IPZERODET_ZERO),1 (IPZERODET_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTOZERO_ON                              = " "0 (AUTO_ZERORING_DISABLED),1 (AUTO_ZEROING_ENABLED)"
    tree.end
    tree "LAB_PS_CTL"
      sgroup "LAB_PS_CTL (at 0x1de50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PS                                    = " "0 (PWM),1 (PULSE_SKIP)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PS_ASYNC                              = " "0 (PWM_ASYNC),1 (PULSE_SKIP_ASYNC)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SEL_DIG_PS                               = " "0 (ANALOG_PS),1 (DIGITAL_PS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SEL_PS_TABLE                             = " "0 (PS_TABLE_0),1 (PS_TABLE_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PS_THRESHOLD                             = " "0 (MA50),1 (MA60),2 (MA70),3 (MA80)"
    tree.end
    tree "LAB_PWM_CTL_1"
      sgroup "LAB_PWM_CTL_1 (at 0x1de51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MAX_DUTY_CYCLE                        = " "0 (DIS_MAX_DUTY),1 (EN_MAX_DUTY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_D_MODULATION                          = " "0 (DIS_D_MODULATION),1 (EN_D_MODULATION)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   MAXD_CLK_SEL                             = " "0 (X1CLK),1 (X2CLK),2 (X3CLK),3 (X4CLK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MAXD_HALF_CLK                            = " "0 (reserved),1 (X0P5CLK_MAXD)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAXD_DLY                                 = " "0 (NO_DLY),1 (X0P25CLK)"
    tree.end
    tree "LAB_PWM_CTL_2"
      sgroup "LAB_PWM_CTL_2 (at 0x1de52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ERR_AMP_GAIN                             = " "0 (HIGH_GAIN),1 (LOW_GAIN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_AUTO_ASYNC                            = " "0 (DIS_AUTO_AYSNC),1 (EN_AUTO_ASYNC)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BLANK_TIME                               = " "0 (NS5),1 (NS10),2 (NS20),3 (NS35)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ASYNC_THRESHOLD                          = " "0 (V4P34),1 (V4P38),2 (V4P427),3 (V4P46)"
    tree.end
    tree "LAB_RDSON_MNGMNT"
      sgroup "LAB_RDSON_MNGMNT (at 0x1de53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   NFET_SLEW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFET_SLEW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NFET_SW_SIZE                             = " "0 (RDSON_QUARTER),1 (RDSON_HALF),2 (RDSON_THREE_FOURTH),3 (RDSON_FULLSIZE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFET_SW_SIZE                             = " "0 (RDSON_QUARTER),1 (RDSON_HALF),2 (RDSON_THREE_FOURTH),3 (RDSON_FULLSIZE)"
    tree.end
    tree "LAB_SHORT_CIRCUIT_CTL"
      sgroup "LAB_SHORT_CIRCUIT_CTL (at 0x1de54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SHORT_CIRCUIT_DEB                        = " "0 (US2),1 (US4),2 (US16),3 (US32)"
    tree.end
    tree "LAB_VREG_OK_CTL"
      sgroup "LAB_VREG_OK_CTL (at 0x1de55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_DEB                              = " "0 (US10),1 (US20),2 (US30),3 (US40)"
    tree.end
    tree "LAB_AFVC"
      sgroup "LAB_AFVC (at 0x1de5d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFVC_ENABLE                              = " "0 (AFVC_DIS),1 (AFVC_EN)"
    tree.end
    tree "LAB_PRECHARGE_CTL"
      sgroup "LAB_PRECHARGE_CTL (at 0x1de5e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FAST_PRECHARGE                           = " "0 (SLOW_PRECHARGE),1 (FAST_PRECHARGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SELECT_THE_MAX_PRECHARGE_TIME            = " "0 (US200),1 (US300),2 (US400),3 (US500)"
    tree.end
    tree "LAB_SOFT_START_CTL"
      sgroup "LAB_SOFT_START_CTL (at 0x1de5f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de5f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde5f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SELECT_THE_MAX_SOFT_START_TIME           = " "0 (US200),1 (US400),2 (US600),3 (US800)"
    tree.end
    tree "LAB_MISC_CTL"
      sgroup "LAB_MISC_CTL (at 0x1de60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AUTO_GM                                  = " "0 (DIS_AUTO_GM),1 (EN_AUTO_GM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TOUCH_WAKE                               = " "0 (DIS_TOUCH_WAKE),1 (EN_TOUCH_WAKE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_SPIKE_SUPPRESS                       = " "0 (EN_SPIKE_SUPPRESS),1 (DIS_SPIKE_SUPPRESS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_NX_ILIMIT                             = " "0 (DIS_NX_ILIMIT),1 (EN_NX_ILIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_SHORT_CIRCUIT_PROTECTION             = " "0 (EN_SCP),1 (DIS_SCP)"
    tree.end
    tree "LAB_PWM_CTRL_3"
      sgroup "LAB_PWM_CTRL_3 (at 0x1de61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIS_MIN_DUTY_CYCLE                       = " "0 (EN_MIN_DUTY),1 (DIS_MIN_DUTY)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   MIND_CLK_SEL                             = " "0 (X1CLK),1 (X2CLK),2 (X3CLK),3 (X8CLK)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   MIND_CLK_SEL_ASYNC                       = " "0 (X8CLK),1 (X10CLK),2 (X11CLK),3 (X12CLK)"
    tree.end
    tree "LAB_PFM_CTL"
      sgroup "LAB_PFM_CTL (at 0x1de62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFM                                   = " "0 (DIS_PFM),1 (EN_PFM)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PFM_HYSTERESIS                           = " "0 (X15MV),1 (X25MV),2 (X35MV),3 (X45MV)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PEAK_CURRENT                         = " "0 (X250MA),1 (X300MA),2 (X350MA),3 (X400MA)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_BLANKING_TIME                        = " "0 (X5NS),1 (X10NS),2 (X15NS),3 (X20NS)"
    tree.end
    tree "LAB_HIGH_BW_CTL"
      sgroup "LAB_HIGH_BW_CTL (at 0x1de63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DOUBLE_SLP_CURR                          = " "0 (X0P5UA),1 (X0P75UA),2 (X1UA),3 (X1P5UA)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DOUBLE_SLP_CAP                           = " "0 (X1P11PF),1 (X1P5PF),2 (X1P87PF),3 (X2P23PF)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   EA_GM                                    = " "0 (X1BY10K),1 (X1BY20K),2 (X1BY30K),3 (X1BY40K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   HALF_CLK_DLY                             = " "0 (X13NS),1 (X9NS),2 (X11NS),3 (X5NS)"
    tree.end
    tree "LAB_SPARE_CTL"
      sgroup "LAB_SPARE_CTL (at 0x1de64)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80de640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   SPARE_BIT                                = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_ACTIVE_LOAD                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_ASYNC                              = " "0, 1"
    tree.end
    tree "LAB_SEC_ACCESS"
      sgroup "LAB_SEC_ACCESS (at 0x1ded0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80ded00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xded00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LAB_PERPH_RESET_CTL1"
      sgroup "LAB_PERPH_RESET_CTL1 (at 0x1ded8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80ded80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xded80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LAB_PERPH_RESET_CTL2"
      sgroup "LAB_PERPH_RESET_CTL2 (at 0x1ded9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80ded90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xded90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "LAB_PERPH_RESET_CTL3"
      sgroup "LAB_PERPH_RESET_CTL3 (at 0x1deda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80deda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "LAB_PERPH_RESET_CTL4"
      sgroup "LAB_PERPH_RESET_CTL4 (at 0x1dedb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LAB_INT_TEST1"
      sgroup "LAB_INT_TEST1 (at 0x1dee0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LAB_INT_TEST_VAL"
      sgroup "LAB_INT_TEST_VAL (at 0x1dee1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SC_ERROR_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LAB_DTEST1_ACCESS"
      sgroup "LAB_DTEST1_ACCESS (at 0x1dee2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (CURR_COMP),2 (LOW_VPH_COMP),3 (ASYNC_READY),4 (VREG_OK_COMP),5 (LAB_EN),6 (SHORT_ALARM),7 (PULSESKIP_COMP)"
    tree.end
    tree "LAB_DTEST2_ACCESS"
      sgroup "LAB_DTEST2_ACCESS (at 0x1dee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (SWIRE_LAB_EN),2 (NGATE),3 (CLOCK_19P2M),4 (ZX_COMP),5 (MIND),6 (PRECHARGE_TIMEOUT),7 (PFM_RDY_COMP)"
    tree.end
    tree "LAB_DTEST3_ACCESS"
      sgroup "LAB_DTEST3_ACCESS (at 0x1dee4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (EN_RISEDLY),2 (PGATE),3 (PFM_COMP),4 (SSEND_COMP),5 (DIG_PS_1),6 (CLK_19P2M_REQ),7 (CLK_DLY)"
    tree.end
    tree "LAB_DTEST4_ACCESS"
      sgroup "LAB_DTEST4_ACCESS (at 0x1dee5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (VOK_DEBOUNCE),2 (SHORT_ALARM_DEBOUNCE),3 (DIS_CHG_FNC),4 (ILIMIT_COMP),5 (DIG_PS_0),6 (CLK_MASK),7 (MAXD)"
    tree.end
    tree "LAB_ATEST1_ACCESS"
      sgroup "LAB_ATEST1_ACCESS (at 0x1dee6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (ERRAMP_OUT),2 (VREF1P25_BUF),3 (PFET_D),4 (ISENSE_ATEST),5 (VC_TRIM_OUT),6 (LOW_VPH_THRESHOLD),7 (PFM_COMP)"
    tree.end
    tree "LAB_ATEST2_ACCESS"
      sgroup "LAB_ATEST2_ACCESS (at 0x1dee7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (VOUT_DIV),2 (VOUT_DIV_VOKCOMP),3 (PVDD_DIV_DUTYLOW),4 (VOUT_1P25),5 (PVDD_DIV_CURR),6 (PGND),7 (VREF_ERRAMP)"
    tree.end
    tree "LAB_ATEST3_ACCESS"
      sgroup "LAB_ATEST3_ACCESS (at 0x1dee8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (VREF_EA_SS),2 (VREF_PS),3 (NFET_DSNS)"
    tree.end
    tree "LAB_ATEST4_ACCESS"
      sgroup "LAB_ATEST4_ACCESS (at 0x1dee9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80dee90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdee90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (VREF_SSEND_COMP),2 (PFET_S),3 (IMAX_VREF)"
    tree.end
    tree "LAB_TEST_CTL"
      sgroup "LAB_TEST_CTL (at 0x1deea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80deea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdeea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_NFET_OVERRIDE                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_OFF_WIRTE_ONCE                     = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODULE_FORCE_ON                          = " "0 (NOT_FORCE_ON),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SCALE_ILIM                               = " "0 (X1),1 (X0P5),2 (X0P33),3 (X0P25)"
    tree.end
    tree "LAB_DEBOUNCER_OVERRIDE"
      sgroup "LAB_DEBOUNCER_OVERRIDE (at 0x1deeb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80deeb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdeeb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEB_VREG_OK                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEB_SC                                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "LAB_TRIM_NUM"
      sgroup "LAB_TRIM_NUM (at 0x1def0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80def00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LAB_TRIM_PWM"
      sgroup "LAB_TRIM_PWM (at 0x1def1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80def10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIM_EN                                  = " "0 (TRIM_ENB),1 (TRIM_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIM_VALUE_SIGN                          = " "0 (NEG_OFFS_ADDING),1 (POS_OFFS_ADDING)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ERR_AMP_OFFSET_TRIM                      = "
    tree.end
    tree "LAB_TRIM_PFM"
      sgroup "LAB_TRIM_PFM (at 0x1def2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        set &access:&cmd_addr %l 0x80def20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xde00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdef20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIM_EN                                  = " "0 (TRIM_ENB),1 (TRIM_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIM_VALUE_SIGN                          = " "0 (NEG_OFFS_ADDING),1 (POS_OFFS_ADDING)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PFM_COMP_OFFSET_TRIM                     = "
    tree.end
  tree.end
tree.end
tree "LPG_CHAN1"
  tree "LPG_CHAN1"
    tree "LPG_CHAN1_REVISION1"
      sgroup "LPG_CHAN1_REVISION1 (at 0x1b100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN1_REVISION2"
      sgroup "LPG_CHAN1_REVISION2 (at 0x1b101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN1_PERPH_TYPE"
      sgroup "LPG_CHAN1_PERPH_TYPE (at 0x1b104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN1_PERPH_SUBTYPE"
      sgroup "LPG_CHAN1_PERPH_SUBTYPE (at 0x1b105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN1_INT_RT_STS"
      sgroup "LPG_CHAN1_INT_RT_STS (at 0x1b110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_SET_TYPE"
      sgroup "LPG_CHAN1_INT_SET_TYPE (at 0x1b111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN1_INT_POLARITY_HIGH (at 0x1b112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_POLARITY_LOW"
      sgroup "LPG_CHAN1_INT_POLARITY_LOW (at 0x1b113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_CLR"
      sgroup "LPG_CHAN1_INT_LATCHED_CLR (at 0x1b114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN1_INT_EN_SET"
      sgroup "LPG_CHAN1_INT_EN_SET (at 0x1b115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_EN_CLR"
      sgroup "LPG_CHAN1_INT_EN_CLR (at 0x1b116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_LATCHED_STS"
      sgroup "LPG_CHAN1_INT_LATCHED_STS (at 0x1b118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN1_INT_PENDING_STS"
      sgroup "LPG_CHAN1_INT_PENDING_STS (at 0x1b119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN1_INT_MID_SEL"
      sgroup "LPG_CHAN1_INT_MID_SEL (at 0x1b11a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN1_INT_PRIORITY"
      sgroup "LPG_CHAN1_INT_PRIORITY (at 0x1b11b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN1_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN1_LPG_PATTERN_CONFIG (at 0x1b140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN1_LPG_PWM_SIZE_CLK (at 0x1b141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN1_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b142)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN1_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN1_LPG_PWM_TYPE_CONFIG (at 0x1b143)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_LSB"
      sgroup "LPG_CHAN1_PWM_VALUE_LSB (at 0x1b144)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN1_PWM_VALUE_MSB"
      sgroup "LPG_CHAN1_PWM_VALUE_MSB (at 0x1b145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN1_ENABLE_CONTROL"
      sgroup "LPG_CHAN1_ENABLE_CONTROL (at 0x1b146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN1_PWM_SYNC"
      sgroup "LPG_CHAN1_PWM_SYNC (at 0x1b147)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN1_RAMP_STEP_DURATION_LSB (at 0x1b150)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN1_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN1_RAMP_STEP_DURATION_MSB (at 0x1b151)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN1_PAUSE_HI_MULTIPLIER"
      sgroup "LPG_CHAN1_PAUSE_HI_MULTIPLIER (at 0x1b152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN1_PAUSE_LO_MULTIPLIER"
      sgroup "LPG_CHAN1_PAUSE_LO_MULTIPLIER (at 0x1b154)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN1_HI_INDEX"
      sgroup "LPG_CHAN1_HI_INDEX (at 0x1b156)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_LO_INDEX"
      sgroup "LPG_CHAN1_LO_INDEX (at 0x1b157)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN1_SEC_ACCESS"
      sgroup "LPG_CHAN1_SEC_ACCESS (at 0x1b1d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN1_PERPH_RESET_CTL2 (at 0x1b1d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN1_PERPH_RESET_CTL3 (at 0x1b1da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN1_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN1_PERPH_RESET_CTL4 (at 0x1b1db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST1"
      sgroup "LPG_CHAN1_INT_TEST1 (at 0x1b1e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN1_INT_TEST_VAL"
      sgroup "LPG_CHAN1_INT_TEST_VAL (at 0x1b1e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN1_TEST1"
      sgroup "LPG_CHAN1_TEST1 (at 0x1b1e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN1_TEST2"
      sgroup "LPG_CHAN1_TEST2 (at 0x1b1e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN1_TEST3"
      sgroup "LPG_CHAN1_TEST3 (at 0x1b1e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN1_TEST4"
      sgroup "LPG_CHAN1_TEST4 (at 0x1b1e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        set &access:&cmd_addr %l 0x80b1e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb1e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN2"
  tree "LPG_CHAN2"
    tree "LPG_CHAN2_REVISION1"
      sgroup "LPG_CHAN2_REVISION1 (at 0x1b200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN2_REVISION2"
      sgroup "LPG_CHAN2_REVISION2 (at 0x1b201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN2_PERPH_TYPE"
      sgroup "LPG_CHAN2_PERPH_TYPE (at 0x1b204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN2_PERPH_SUBTYPE"
      sgroup "LPG_CHAN2_PERPH_SUBTYPE (at 0x1b205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN2_INT_RT_STS"
      sgroup "LPG_CHAN2_INT_RT_STS (at 0x1b210)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_SET_TYPE"
      sgroup "LPG_CHAN2_INT_SET_TYPE (at 0x1b211)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN2_INT_POLARITY_HIGH (at 0x1b212)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_POLARITY_LOW"
      sgroup "LPG_CHAN2_INT_POLARITY_LOW (at 0x1b213)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_CLR"
      sgroup "LPG_CHAN2_INT_LATCHED_CLR (at 0x1b214)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN2_INT_EN_SET"
      sgroup "LPG_CHAN2_INT_EN_SET (at 0x1b215)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_EN_CLR"
      sgroup "LPG_CHAN2_INT_EN_CLR (at 0x1b216)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_LATCHED_STS"
      sgroup "LPG_CHAN2_INT_LATCHED_STS (at 0x1b218)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN2_INT_PENDING_STS"
      sgroup "LPG_CHAN2_INT_PENDING_STS (at 0x1b219)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN2_INT_MID_SEL"
      sgroup "LPG_CHAN2_INT_MID_SEL (at 0x1b21a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN2_INT_PRIORITY"
      sgroup "LPG_CHAN2_INT_PRIORITY (at 0x1b21b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN2_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN2_LPG_PATTERN_CONFIG (at 0x1b240)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN2_LPG_PWM_SIZE_CLK (at 0x1b241)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN2_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b242)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN2_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN2_LPG_PWM_TYPE_CONFIG (at 0x1b243)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_LSB"
      sgroup "LPG_CHAN2_PWM_VALUE_LSB (at 0x1b244)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN2_PWM_VALUE_MSB"
      sgroup "LPG_CHAN2_PWM_VALUE_MSB (at 0x1b245)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN2_ENABLE_CONTROL"
      sgroup "LPG_CHAN2_ENABLE_CONTROL (at 0x1b246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN2_PWM_SYNC"
      sgroup "LPG_CHAN2_PWM_SYNC (at 0x1b247)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN2_RAMP_STEP_DURATION_LSB (at 0x1b250)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN2_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN2_RAMP_STEP_DURATION_MSB (at 0x1b251)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN2_PAUSE_HI_MULTIPLIER"
      sgroup "LPG_CHAN2_PAUSE_HI_MULTIPLIER (at 0x1b252)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN2_PAUSE_LO_MULTIPLIER"
      sgroup "LPG_CHAN2_PAUSE_LO_MULTIPLIER (at 0x1b254)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN2_HI_INDEX"
      sgroup "LPG_CHAN2_HI_INDEX (at 0x1b256)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_LO_INDEX"
      sgroup "LPG_CHAN2_LO_INDEX (at 0x1b257)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN2_SEC_ACCESS"
      sgroup "LPG_CHAN2_SEC_ACCESS (at 0x1b2d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN2_PERPH_RESET_CTL2 (at 0x1b2d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN2_PERPH_RESET_CTL3 (at 0x1b2da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN2_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN2_PERPH_RESET_CTL4 (at 0x1b2db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST1"
      sgroup "LPG_CHAN2_INT_TEST1 (at 0x1b2e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN2_INT_TEST_VAL"
      sgroup "LPG_CHAN2_INT_TEST_VAL (at 0x1b2e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN2_TEST1"
      sgroup "LPG_CHAN2_TEST1 (at 0x1b2e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN2_TEST2"
      sgroup "LPG_CHAN2_TEST2 (at 0x1b2e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN2_TEST3"
      sgroup "LPG_CHAN2_TEST3 (at 0x1b2e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN2_TEST4"
      sgroup "LPG_CHAN2_TEST4 (at 0x1b2e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        set &access:&cmd_addr %l 0x80b2e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb2e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN3"
  tree "LPG_CHAN3"
    tree "LPG_CHAN3_REVISION1"
      sgroup "LPG_CHAN3_REVISION1 (at 0x1b300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN3_REVISION2"
      sgroup "LPG_CHAN3_REVISION2 (at 0x1b301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN3_PERPH_TYPE"
      sgroup "LPG_CHAN3_PERPH_TYPE (at 0x1b304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN3_PERPH_SUBTYPE"
      sgroup "LPG_CHAN3_PERPH_SUBTYPE (at 0x1b305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN3_INT_RT_STS"
      sgroup "LPG_CHAN3_INT_RT_STS (at 0x1b310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_SET_TYPE"
      sgroup "LPG_CHAN3_INT_SET_TYPE (at 0x1b311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN3_INT_POLARITY_HIGH (at 0x1b312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_POLARITY_LOW"
      sgroup "LPG_CHAN3_INT_POLARITY_LOW (at 0x1b313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_CLR"
      sgroup "LPG_CHAN3_INT_LATCHED_CLR (at 0x1b314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN3_INT_EN_SET"
      sgroup "LPG_CHAN3_INT_EN_SET (at 0x1b315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_EN_CLR"
      sgroup "LPG_CHAN3_INT_EN_CLR (at 0x1b316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_LATCHED_STS"
      sgroup "LPG_CHAN3_INT_LATCHED_STS (at 0x1b318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN3_INT_PENDING_STS"
      sgroup "LPG_CHAN3_INT_PENDING_STS (at 0x1b319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN3_INT_MID_SEL"
      sgroup "LPG_CHAN3_INT_MID_SEL (at 0x1b31a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN3_INT_PRIORITY"
      sgroup "LPG_CHAN3_INT_PRIORITY (at 0x1b31b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN3_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN3_LPG_PATTERN_CONFIG (at 0x1b340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN3_LPG_PWM_SIZE_CLK (at 0x1b341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN3_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b342)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN3_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN3_LPG_PWM_TYPE_CONFIG (at 0x1b343)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_LSB"
      sgroup "LPG_CHAN3_PWM_VALUE_LSB (at 0x1b344)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN3_PWM_VALUE_MSB"
      sgroup "LPG_CHAN3_PWM_VALUE_MSB (at 0x1b345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN3_ENABLE_CONTROL"
      sgroup "LPG_CHAN3_ENABLE_CONTROL (at 0x1b346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN3_PWM_SYNC"
      sgroup "LPG_CHAN3_PWM_SYNC (at 0x1b347)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN3_RAMP_STEP_DURATION_LSB (at 0x1b350)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN3_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN3_RAMP_STEP_DURATION_MSB (at 0x1b351)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN3_PAUSE_HI_MULTIPLIER"
      sgroup "LPG_CHAN3_PAUSE_HI_MULTIPLIER (at 0x1b352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN3_PAUSE_LO_MULTIPLIER"
      sgroup "LPG_CHAN3_PAUSE_LO_MULTIPLIER (at 0x1b354)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN3_HI_INDEX"
      sgroup "LPG_CHAN3_HI_INDEX (at 0x1b356)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_LO_INDEX"
      sgroup "LPG_CHAN3_LO_INDEX (at 0x1b357)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN3_SEC_ACCESS"
      sgroup "LPG_CHAN3_SEC_ACCESS (at 0x1b3d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN3_PERPH_RESET_CTL2 (at 0x1b3d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN3_PERPH_RESET_CTL3 (at 0x1b3da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN3_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN3_PERPH_RESET_CTL4 (at 0x1b3db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST1"
      sgroup "LPG_CHAN3_INT_TEST1 (at 0x1b3e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN3_INT_TEST_VAL"
      sgroup "LPG_CHAN3_INT_TEST_VAL (at 0x1b3e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN3_TEST1"
      sgroup "LPG_CHAN3_TEST1 (at 0x1b3e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN3_TEST2"
      sgroup "LPG_CHAN3_TEST2 (at 0x1b3e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN3_TEST3"
      sgroup "LPG_CHAN3_TEST3 (at 0x1b3e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN3_TEST4"
      sgroup "LPG_CHAN3_TEST4 (at 0x1b3e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        set &access:&cmd_addr %l 0x80b3e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb3e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN4"
  tree "LPG_CHAN4"
    tree "LPG_CHAN4_REVISION1"
      sgroup "LPG_CHAN4_REVISION1 (at 0x1b400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN4_REVISION2"
      sgroup "LPG_CHAN4_REVISION2 (at 0x1b401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN4_PERPH_TYPE"
      sgroup "LPG_CHAN4_PERPH_TYPE (at 0x1b404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN4_PERPH_SUBTYPE"
      sgroup "LPG_CHAN4_PERPH_SUBTYPE (at 0x1b405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN4_INT_RT_STS"
      sgroup "LPG_CHAN4_INT_RT_STS (at 0x1b410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_SET_TYPE"
      sgroup "LPG_CHAN4_INT_SET_TYPE (at 0x1b411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN4_INT_POLARITY_HIGH (at 0x1b412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_POLARITY_LOW"
      sgroup "LPG_CHAN4_INT_POLARITY_LOW (at 0x1b413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_CLR"
      sgroup "LPG_CHAN4_INT_LATCHED_CLR (at 0x1b414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN4_INT_EN_SET"
      sgroup "LPG_CHAN4_INT_EN_SET (at 0x1b415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_EN_CLR"
      sgroup "LPG_CHAN4_INT_EN_CLR (at 0x1b416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_LATCHED_STS"
      sgroup "LPG_CHAN4_INT_LATCHED_STS (at 0x1b418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN4_INT_PENDING_STS"
      sgroup "LPG_CHAN4_INT_PENDING_STS (at 0x1b419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN4_INT_MID_SEL"
      sgroup "LPG_CHAN4_INT_MID_SEL (at 0x1b41a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b41a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN4_INT_PRIORITY"
      sgroup "LPG_CHAN4_INT_PRIORITY (at 0x1b41b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b41b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN4_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN4_LPG_PATTERN_CONFIG (at 0x1b440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN4_LPG_PWM_SIZE_CLK (at 0x1b441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN4_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b442)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN4_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN4_LPG_PWM_TYPE_CONFIG (at 0x1b443)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_LSB"
      sgroup "LPG_CHAN4_PWM_VALUE_LSB (at 0x1b444)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN4_PWM_VALUE_MSB"
      sgroup "LPG_CHAN4_PWM_VALUE_MSB (at 0x1b445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN4_ENABLE_CONTROL"
      sgroup "LPG_CHAN4_ENABLE_CONTROL (at 0x1b446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN4_PWM_SYNC"
      sgroup "LPG_CHAN4_PWM_SYNC (at 0x1b447)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN4_RAMP_STEP_DURATION_LSB (at 0x1b450)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN4_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN4_RAMP_STEP_DURATION_MSB (at 0x1b451)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN4_PAUSE_HI_MULTIPLIER"
      sgroup "LPG_CHAN4_PAUSE_HI_MULTIPLIER (at 0x1b452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN4_PAUSE_LO_MULTIPLIER"
      sgroup "LPG_CHAN4_PAUSE_LO_MULTIPLIER (at 0x1b454)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN4_HI_INDEX"
      sgroup "LPG_CHAN4_HI_INDEX (at 0x1b456)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_LO_INDEX"
      sgroup "LPG_CHAN4_LO_INDEX (at 0x1b457)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN4_SEC_ACCESS"
      sgroup "LPG_CHAN4_SEC_ACCESS (at 0x1b4d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN4_PERPH_RESET_CTL2 (at 0x1b4d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN4_PERPH_RESET_CTL3 (at 0x1b4da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN4_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN4_PERPH_RESET_CTL4 (at 0x1b4db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST1"
      sgroup "LPG_CHAN4_INT_TEST1 (at 0x1b4e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN4_INT_TEST_VAL"
      sgroup "LPG_CHAN4_INT_TEST_VAL (at 0x1b4e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN4_TEST1"
      sgroup "LPG_CHAN4_TEST1 (at 0x1b4e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN4_TEST2"
      sgroup "LPG_CHAN4_TEST2 (at 0x1b4e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN4_TEST3"
      sgroup "LPG_CHAN4_TEST3 (at 0x1b4e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN4_TEST4"
      sgroup "LPG_CHAN4_TEST4 (at 0x1b4e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        set &access:&cmd_addr %l 0x80b4e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb4e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN5"
  tree "LPG_CHAN5"
    tree "LPG_CHAN5_REVISION1"
      sgroup "LPG_CHAN5_REVISION1 (at 0x1b500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN5_REVISION2"
      sgroup "LPG_CHAN5_REVISION2 (at 0x1b501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN5_PERPH_TYPE"
      sgroup "LPG_CHAN5_PERPH_TYPE (at 0x1b504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN5_PERPH_SUBTYPE"
      sgroup "LPG_CHAN5_PERPH_SUBTYPE (at 0x1b505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN5_INT_RT_STS"
      sgroup "LPG_CHAN5_INT_RT_STS (at 0x1b510)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN5_INT_SET_TYPE"
      sgroup "LPG_CHAN5_INT_SET_TYPE (at 0x1b511)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN5_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN5_INT_POLARITY_HIGH (at 0x1b512)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_POLARITY_LOW"
      sgroup "LPG_CHAN5_INT_POLARITY_LOW (at 0x1b513)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_LATCHED_CLR"
      sgroup "LPG_CHAN5_INT_LATCHED_CLR (at 0x1b514)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN5_INT_EN_SET"
      sgroup "LPG_CHAN5_INT_EN_SET (at 0x1b515)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_EN_CLR"
      sgroup "LPG_CHAN5_INT_EN_CLR (at 0x1b516)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_LATCHED_STS"
      sgroup "LPG_CHAN5_INT_LATCHED_STS (at 0x1b518)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN5_INT_PENDING_STS"
      sgroup "LPG_CHAN5_INT_PENDING_STS (at 0x1b519)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN5_INT_MID_SEL"
      sgroup "LPG_CHAN5_INT_MID_SEL (at 0x1b51a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b51a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN5_INT_PRIORITY"
      sgroup "LPG_CHAN5_INT_PRIORITY (at 0x1b51b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b51b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN5_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN5_LPG_PATTERN_CONFIG (at 0x1b540)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN5_LPG_PWM_SIZE_CLK (at 0x1b541)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN5_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b542)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN5_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN5_LPG_PWM_TYPE_CONFIG (at 0x1b543)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN5_PWM_VALUE_LSB"
      sgroup "LPG_CHAN5_PWM_VALUE_LSB (at 0x1b544)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN5_PWM_VALUE_MSB"
      sgroup "LPG_CHAN5_PWM_VALUE_MSB (at 0x1b545)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN5_ENABLE_CONTROL"
      sgroup "LPG_CHAN5_ENABLE_CONTROL (at 0x1b546)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN5_PWM_SYNC"
      sgroup "LPG_CHAN5_PWM_SYNC (at 0x1b547)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN5_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN5_RAMP_STEP_DURATION_LSB (at 0x1b550)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN5_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN5_RAMP_STEP_DURATION_MSB (at 0x1b551)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN5_PAUSE_HI_MULTIPLIER"
      sgroup "LPG_CHAN5_PAUSE_HI_MULTIPLIER (at 0x1b552)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN5_PAUSE_LO_MULTIPLIER"
      sgroup "LPG_CHAN5_PAUSE_LO_MULTIPLIER (at 0x1b554)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN5_HI_INDEX"
      sgroup "LPG_CHAN5_HI_INDEX (at 0x1b556)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN5_LO_INDEX"
      sgroup "LPG_CHAN5_LO_INDEX (at 0x1b557)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN5_SEC_ACCESS"
      sgroup "LPG_CHAN5_SEC_ACCESS (at 0x1b5d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN5_PERPH_RESET_CTL2 (at 0x1b5d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN5_PERPH_RESET_CTL3 (at 0x1b5da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN5_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN5_PERPH_RESET_CTL4 (at 0x1b5db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN5_INT_TEST1"
      sgroup "LPG_CHAN5_INT_TEST1 (at 0x1b5e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN5_INT_TEST_VAL"
      sgroup "LPG_CHAN5_INT_TEST_VAL (at 0x1b5e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN5_TEST1"
      sgroup "LPG_CHAN5_TEST1 (at 0x1b5e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN5_TEST2"
      sgroup "LPG_CHAN5_TEST2 (at 0x1b5e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN5_TEST3"
      sgroup "LPG_CHAN5_TEST3 (at 0x1b5e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN5_TEST4"
      sgroup "LPG_CHAN5_TEST4 (at 0x1b5e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        set &access:&cmd_addr %l 0x80b5e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb5e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_CHAN6"
  tree "LPG_CHAN6"
    tree "LPG_CHAN6_REVISION1"
      sgroup "LPG_CHAN6_REVISION1 (at 0x1b600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_CHAN6_REVISION2"
      sgroup "LPG_CHAN6_REVISION2 (at 0x1b601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_CHAN6_PERPH_TYPE"
      sgroup "LPG_CHAN6_PERPH_TYPE (at 0x1b604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_CHAN6_PERPH_SUBTYPE"
      sgroup "LPG_CHAN6_PERPH_SUBTYPE (at 0x1b605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_CHAN6_INT_RT_STS"
      sgroup "LPG_CHAN6_INT_RT_STS (at 0x1b610)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_RT_STS                           = " "0, 1"
    tree.end
    tree "LPG_CHAN6_INT_SET_TYPE"
      sgroup "LPG_CHAN6_INT_SET_TYPE (at 0x1b611)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "LPG_CHAN6_INT_POLARITY_HIGH"
      sgroup "LPG_CHAN6_INT_POLARITY_HIGH (at 0x1b612)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_POLARITY_LOW"
      sgroup "LPG_CHAN6_INT_POLARITY_LOW (at 0x1b613)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_LATCHED_CLR"
      sgroup "LPG_CHAN6_INT_LATCHED_CLR (at 0x1b614)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "LPG_CHAN6_INT_EN_SET"
      sgroup "LPG_CHAN6_INT_EN_SET (at 0x1b615)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_EN_CLR"
      sgroup "LPG_CHAN6_INT_EN_CLR (at 0x1b616)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_LATCHED_STS"
      sgroup "LPG_CHAN6_INT_LATCHED_STS (at 0x1b618)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "LPG_CHAN6_INT_PENDING_STS"
      sgroup "LPG_CHAN6_INT_PENDING_STS (at 0x1b619)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "LPG_CHAN6_INT_MID_SEL"
      sgroup "LPG_CHAN6_INT_MID_SEL (at 0x1b61a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b61a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "LPG_CHAN6_INT_PRIORITY"
      sgroup "LPG_CHAN6_INT_PRIORITY (at 0x1b61b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b61b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "LPG_CHAN6_LPG_PATTERN_CONFIG"
      sgroup "LPG_CHAN6_LPG_PATTERN_CONFIG (at 0x1b640)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RAMP_DIRECTION                           = " "0 (RAMP_HI_TO_LO),1 (RAMP_LO_TO_HI)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PATTERN_REPEAT                           = " "0 (LOOPING_DIS),1 (LOOPING_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMP_TOGGLE                              = " "0 (TOGGLE_START),1 (TOGGLE_INDEX)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PAUSE_HI                              = " "0 (PAUSE_HI_DIS),1 (PAUSE_HI_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_PAUSE_LO                              = " "0 (PAUSE_LO_DIS),1 (PAUSE_LO_EN)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_SIZE_CLK"
      sgroup "LPG_CHAN6_LPG_PWM_SIZE_CLK (at 0x1b641)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_FREQ_PREDIV_CLK"
      sgroup "LPG_CHAN6_LPG_PWM_FREQ_PREDIV_CLK (at 0x1b642)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "LPG_CHAN6_LPG_PWM_TYPE_CONFIG"
      sgroup "LPG_CHAN6_LPG_PWM_TYPE_CONFIG (at 0x1b643)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "LPG_CHAN6_PWM_VALUE_LSB"
      sgroup "LPG_CHAN6_PWM_VALUE_LSB (at 0x1b644)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "LPG_CHAN6_PWM_VALUE_MSB"
      sgroup "LPG_CHAN6_PWM_VALUE_MSB (at 0x1b645)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "LPG_CHAN6_ENABLE_CONTROL"
      sgroup "LPG_CHAN6_ENABLE_CONTROL (at 0x1b646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_SLICE                                 = " "0 (SLICE_DIS),1 (SLICE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SRC_SELECT                           = " "0 (LUT),1 (PWM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_RAMP_GEN                              = " "0 (RAMP_GEN_DIS),1 (RAMP_GEN_EN)"
    tree.end
    tree "LPG_CHAN6_PWM_SYNC"
      sgroup "LPG_CHAN6_PWM_SYNC (at 0x1b647)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0 (NO_SYNC),1 (SYNC)"
    tree.end
    tree "LPG_CHAN6_RAMP_STEP_DURATION_LSB"
      sgroup "LPG_CHAN6_RAMP_STEP_DURATION_LSB (at 0x1b650)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAMP_STEP_DURATION_LSB                   = "
    tree.end
    tree "LPG_CHAN6_RAMP_STEP_DURATION_MSB"
      sgroup "LPG_CHAN6_RAMP_STEP_DURATION_MSB (at 0x1b651)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_STEP_DURATION_MSB                   = " "0, 1"
    tree.end
    tree "LPG_CHAN6_PAUSE_HI_MULTIPLIER"
      sgroup "LPG_CHAN6_PAUSE_HI_MULTIPLIER (at 0x1b652)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_HI_MULT                            = "
    tree.end
    tree "LPG_CHAN6_PAUSE_LO_MULTIPLIER"
      sgroup "LPG_CHAN6_PAUSE_LO_MULTIPLIER (at 0x1b654)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PAUSE_LO_MULT                            = "
    tree.end
    tree "LPG_CHAN6_HI_INDEX"
      sgroup "LPG_CHAN6_HI_INDEX (at 0x1b656)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   HI_INDEX                                 = "
    tree.end
    tree "LPG_CHAN6_LO_INDEX"
      sgroup "LPG_CHAN6_LO_INDEX (at 0x1b657)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LO_INDEX                                 = "
    tree.end
    tree "LPG_CHAN6_SEC_ACCESS"
      sgroup "LPG_CHAN6_SEC_ACCESS (at 0x1b6d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL2"
      sgroup "LPG_CHAN6_PERPH_RESET_CTL2 (at 0x1b6d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL3"
      sgroup "LPG_CHAN6_PERPH_RESET_CTL3 (at 0x1b6da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_CHAN6_PERPH_RESET_CTL4"
      sgroup "LPG_CHAN6_PERPH_RESET_CTL4 (at 0x1b6db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "LPG_CHAN6_INT_TEST1"
      sgroup "LPG_CHAN6_INT_TEST1 (at 0x1b6e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LPG_CHAN6_INT_TEST_VAL"
      sgroup "LPG_CHAN6_INT_TEST_VAL (at 0x1b6e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INT_TEST_VAL                         = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "LPG_CHAN6_TEST1"
      sgroup "LPG_CHAN6_TEST1 (at 0x1b6e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN6_TEST2"
      sgroup "LPG_CHAN6_TEST2 (at 0x1b6e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN6_TEST3"
      sgroup "LPG_CHAN6_TEST3 (at 0x1b6e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST3                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LPG_CHAN6_TEST4"
      sgroup "LPG_CHAN6_TEST4 (at 0x1b6e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        set &access:&cmd_addr %l 0x80b6e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb6e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "LPG_LUT"
  tree "LPG_LUT"
    tree "LPG_LUT_REVISION1"
      sgroup "LPG_LUT_REVISION1 (at 0x1b000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LPG_LUT_REVISION2"
      sgroup "LPG_LUT_REVISION2 (at 0x1b001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LPG_LUT_PERPH_TYPE"
      sgroup "LPG_LUT_PERPH_TYPE (at 0x1b004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LPG_LUT_PERPH_SUBTYPE"
      sgroup "LPG_LUT_PERPH_SUBTYPE (at 0x1b005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LPG_LUT_LUT0_LSB"
      sgroup "LPG_LUT_LUT0_LSB (at 0x1b040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT0_MSB"
      sgroup "LPG_LUT_LUT0_MSB (at 0x1b041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT1_LSB"
      sgroup "LPG_LUT_LUT1_LSB (at 0x1b042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT1_MSB"
      sgroup "LPG_LUT_LUT1_MSB (at 0x1b043)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT2_LSB"
      sgroup "LPG_LUT_LUT2_LSB (at 0x1b044)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT2_MSB"
      sgroup "LPG_LUT_LUT2_MSB (at 0x1b045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT3_LSB"
      sgroup "LPG_LUT_LUT3_LSB (at 0x1b046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT3_MSB"
      sgroup "LPG_LUT_LUT3_MSB (at 0x1b047)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT4_LSB"
      sgroup "LPG_LUT_LUT4_LSB (at 0x1b048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT4_MSB"
      sgroup "LPG_LUT_LUT4_MSB (at 0x1b049)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT5_LSB"
      sgroup "LPG_LUT_LUT5_LSB (at 0x1b04a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT5_MSB"
      sgroup "LPG_LUT_LUT5_MSB (at 0x1b04b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b04b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb04b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT6_LSB"
      sgroup "LPG_LUT_LUT6_LSB (at 0x1b04c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT6_MSB"
      sgroup "LPG_LUT_LUT6_MSB (at 0x1b04d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b04d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb04d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT7_LSB"
      sgroup "LPG_LUT_LUT7_LSB (at 0x1b04e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b04e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb04e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT7_MSB"
      sgroup "LPG_LUT_LUT7_MSB (at 0x1b04f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b04f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb04f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT8_LSB"
      sgroup "LPG_LUT_LUT8_LSB (at 0x1b050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT8_MSB"
      sgroup "LPG_LUT_LUT8_MSB (at 0x1b051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT9_LSB"
      sgroup "LPG_LUT_LUT9_LSB (at 0x1b052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT9_MSB"
      sgroup "LPG_LUT_LUT9_MSB (at 0x1b053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT10_LSB"
      sgroup "LPG_LUT_LUT10_LSB (at 0x1b054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT10_MSB"
      sgroup "LPG_LUT_LUT10_MSB (at 0x1b055)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT11_LSB"
      sgroup "LPG_LUT_LUT11_LSB (at 0x1b056)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT11_MSB"
      sgroup "LPG_LUT_LUT11_MSB (at 0x1b057)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT12_LSB"
      sgroup "LPG_LUT_LUT12_LSB (at 0x1b058)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT12_MSB"
      sgroup "LPG_LUT_LUT12_MSB (at 0x1b059)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT13_LSB"
      sgroup "LPG_LUT_LUT13_LSB (at 0x1b05a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b05a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb05a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT13_MSB"
      sgroup "LPG_LUT_LUT13_MSB (at 0x1b05b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b05b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb05b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT14_LSB"
      sgroup "LPG_LUT_LUT14_LSB (at 0x1b05c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b05c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb05c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT14_MSB"
      sgroup "LPG_LUT_LUT14_MSB (at 0x1b05d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b05d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb05d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT15_LSB"
      sgroup "LPG_LUT_LUT15_LSB (at 0x1b05e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b05e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb05e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT15_MSB"
      sgroup "LPG_LUT_LUT15_MSB (at 0x1b05f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b05f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb05f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT16_LSB"
      sgroup "LPG_LUT_LUT16_LSB (at 0x1b060)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT16_MSB"
      sgroup "LPG_LUT_LUT16_MSB (at 0x1b061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT17_LSB"
      sgroup "LPG_LUT_LUT17_LSB (at 0x1b062)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT17_MSB"
      sgroup "LPG_LUT_LUT17_MSB (at 0x1b063)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT18_LSB"
      sgroup "LPG_LUT_LUT18_LSB (at 0x1b064)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT18_MSB"
      sgroup "LPG_LUT_LUT18_MSB (at 0x1b065)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT19_LSB"
      sgroup "LPG_LUT_LUT19_LSB (at 0x1b066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT19_MSB"
      sgroup "LPG_LUT_LUT19_MSB (at 0x1b067)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT20_LSB"
      sgroup "LPG_LUT_LUT20_LSB (at 0x1b068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT20_MSB"
      sgroup "LPG_LUT_LUT20_MSB (at 0x1b069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT21_LSB"
      sgroup "LPG_LUT_LUT21_LSB (at 0x1b06a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b06a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb06a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT21_MSB"
      sgroup "LPG_LUT_LUT21_MSB (at 0x1b06b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b06b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb06b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT22_LSB"
      sgroup "LPG_LUT_LUT22_LSB (at 0x1b06c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b06c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb06c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT22_MSB"
      sgroup "LPG_LUT_LUT22_MSB (at 0x1b06d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b06d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb06d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT23_LSB"
      sgroup "LPG_LUT_LUT23_LSB (at 0x1b06e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b06e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb06e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT23_MSB"
      sgroup "LPG_LUT_LUT23_MSB (at 0x1b06f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b06f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb06f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT24_LSB"
      sgroup "LPG_LUT_LUT24_LSB (at 0x1b070)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT24_MSB"
      sgroup "LPG_LUT_LUT24_MSB (at 0x1b071)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT25_LSB"
      sgroup "LPG_LUT_LUT25_LSB (at 0x1b072)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT25_MSB"
      sgroup "LPG_LUT_LUT25_MSB (at 0x1b073)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT26_LSB"
      sgroup "LPG_LUT_LUT26_LSB (at 0x1b074)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT26_MSB"
      sgroup "LPG_LUT_LUT26_MSB (at 0x1b075)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT27_LSB"
      sgroup "LPG_LUT_LUT27_LSB (at 0x1b076)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT27_MSB"
      sgroup "LPG_LUT_LUT27_MSB (at 0x1b077)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT28_LSB"
      sgroup "LPG_LUT_LUT28_LSB (at 0x1b078)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT28_MSB"
      sgroup "LPG_LUT_LUT28_MSB (at 0x1b079)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT29_LSB"
      sgroup "LPG_LUT_LUT29_LSB (at 0x1b07a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b07a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb07a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT29_MSB"
      sgroup "LPG_LUT_LUT29_MSB (at 0x1b07b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b07b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb07b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT30_LSB"
      sgroup "LPG_LUT_LUT30_LSB (at 0x1b07c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b07c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb07c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT30_MSB"
      sgroup "LPG_LUT_LUT30_MSB (at 0x1b07d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b07d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb07d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT31_LSB"
      sgroup "LPG_LUT_LUT31_LSB (at 0x1b07e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b07e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb07e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT31_MSB"
      sgroup "LPG_LUT_LUT31_MSB (at 0x1b07f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b07f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb07f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT32_LSB"
      sgroup "LPG_LUT_LUT32_LSB (at 0x1b080)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT32_MSB"
      sgroup "LPG_LUT_LUT32_MSB (at 0x1b081)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT33_LSB"
      sgroup "LPG_LUT_LUT33_LSB (at 0x1b082)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT33_MSB"
      sgroup "LPG_LUT_LUT33_MSB (at 0x1b083)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT34_LSB"
      sgroup "LPG_LUT_LUT34_LSB (at 0x1b084)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT34_MSB"
      sgroup "LPG_LUT_LUT34_MSB (at 0x1b085)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT35_LSB"
      sgroup "LPG_LUT_LUT35_LSB (at 0x1b086)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT35_MSB"
      sgroup "LPG_LUT_LUT35_MSB (at 0x1b087)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT36_LSB"
      sgroup "LPG_LUT_LUT36_LSB (at 0x1b088)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT36_MSB"
      sgroup "LPG_LUT_LUT36_MSB (at 0x1b089)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT37_LSB"
      sgroup "LPG_LUT_LUT37_LSB (at 0x1b08a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b08a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb08a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT37_MSB"
      sgroup "LPG_LUT_LUT37_MSB (at 0x1b08b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b08b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb08b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT38_LSB"
      sgroup "LPG_LUT_LUT38_LSB (at 0x1b08c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b08c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb08c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT38_MSB"
      sgroup "LPG_LUT_LUT38_MSB (at 0x1b08d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b08d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb08d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT39_LSB"
      sgroup "LPG_LUT_LUT39_LSB (at 0x1b08e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b08e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb08e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT39_MSB"
      sgroup "LPG_LUT_LUT39_MSB (at 0x1b08f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b08f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb08f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT40_LSB"
      sgroup "LPG_LUT_LUT40_LSB (at 0x1b090)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT40_MSB"
      sgroup "LPG_LUT_LUT40_MSB (at 0x1b091)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT41_LSB"
      sgroup "LPG_LUT_LUT41_LSB (at 0x1b092)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT41_MSB"
      sgroup "LPG_LUT_LUT41_MSB (at 0x1b093)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT42_LSB"
      sgroup "LPG_LUT_LUT42_LSB (at 0x1b094)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT42_MSB"
      sgroup "LPG_LUT_LUT42_MSB (at 0x1b095)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT43_LSB"
      sgroup "LPG_LUT_LUT43_LSB (at 0x1b096)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT43_MSB"
      sgroup "LPG_LUT_LUT43_MSB (at 0x1b097)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT44_LSB"
      sgroup "LPG_LUT_LUT44_LSB (at 0x1b098)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT44_MSB"
      sgroup "LPG_LUT_LUT44_MSB (at 0x1b099)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT45_LSB"
      sgroup "LPG_LUT_LUT45_LSB (at 0x1b09a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b09a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb09a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT45_MSB"
      sgroup "LPG_LUT_LUT45_MSB (at 0x1b09b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b09b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb09b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT46_LSB"
      sgroup "LPG_LUT_LUT46_LSB (at 0x1b09c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b09c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb09c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT46_MSB"
      sgroup "LPG_LUT_LUT46_MSB (at 0x1b09d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b09d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb09d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT47_LSB"
      sgroup "LPG_LUT_LUT47_LSB (at 0x1b09e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b09e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb09e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT47_MSB"
      sgroup "LPG_LUT_LUT47_MSB (at 0x1b09f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b09f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb09f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_LUT48_LSB"
      sgroup "LPG_LUT_LUT48_LSB (at 0x1b0a0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "LPG_LUT_LUT48_MSB"
      sgroup "LPG_LUT_LUT48_MSB (at 0x1b0a1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DATA                                     = " "0, 1"
    tree.end
    tree "LPG_LUT_RAMP_CONTROL"
      sgroup "LPG_LUT_RAMP_CONTROL (at 0x1b0c8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S8_RAMP_START                            = " "0 (S8_RAMP_DIS),1 (S8_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   S7_RAMP_START                            = " "0 (S7_RAMP_DIS),1 (S7_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   S6_RAMP_START                            = " "0 (S6_RAMP_DIS),1 (S6_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   S5_RAMP_START                            = " "0 (S5_RAMP_DIS),1 (S5_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   S4_RAMP_START                            = " "0 (S4_RAMP_DIS),1 (S4_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   S3_RAMP_START                            = " "0 (S3_RAMP_DIS),1 (S3_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   S2_RAMP_START                            = " "0 (S2_RAMP_DIS),1 (S2_RAMP_START)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   S1_RAMP_START                            = " "0 (S1_RAMP_DIS),1 (S1_RAMP_START)"
    tree.end
    tree "LPG_LUT_SEC_ACCESS"
      sgroup "LPG_LUT_SEC_ACCESS (at 0x1b0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL2"
      sgroup "LPG_LUT_PERPH_RESET_CTL2 (at 0x1b0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL3"
      sgroup "LPG_LUT_PERPH_RESET_CTL3 (at 0x1b0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LPG_LUT_PERPH_RESET_CTL4"
      sgroup "LPG_LUT_PERPH_RESET_CTL4 (at 0x1b0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        set &access:&cmd_addr %l 0x80b0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xb000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_IS_OK)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STARTUP_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AVDD_FILTER_EN                           = " "0 (AVDD_FILTER_DISABLED),1 (AVDD_FILTER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TEMP_COMP_OFFSET_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBG_OK_DELAY                             = " "0, 1"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0, 1"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MANUAL_CAL_MODE                          = " "0, 1"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_VREF_0P625_OFF                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VREF_0P3125_OFF                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FORCE_MBG_OK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FORCE_STARTUP_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CC_CAL_HI_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_CAL_LO_EN                             = " "0, 1"
    tree.end
    tree "MBG1_AUTOCAL_CTRL"
      sgroup "MBG1_AUTOCAL_CTRL (at 0x2ce4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MBG_TEMP_CAL_CTRL                        = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AUTO_CAL_CLK_CTRL                        = " "0 (CAL_CLK_CTRL0),1 (CAL_CLK_CTRL1),2 (CAL_CLK_CTRL2),3 (CAL_CLK_CTRL3)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AUTOCAL_CAL_EN                           = " "0, 1"
    tree.end
    tree "MBG1_AUTOCAL_RD1"
      sgroup "MBG1_AUTOCAL_RD1 (at 0x2ce5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AUTOCAL_DONE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTOCAL_FAULT                            = " "0, 1"
    tree.end
    tree "MBG1_AUTOCAL_RD2"
      sgroup "MBG1_AUTOCAL_RD2 (at 0x2ce6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   AUTOCAL_CODE                             = "
    tree.end
    tree "MBG1_TEST_MBG_OK_OFFSET"
      sgroup "MBG1_TEST_MBG_OK_OFFSET (at 0x2ce7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   MBG_OK_OFFSET_CTRL                       = "
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VREF_1P25_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TEMP_COMP_OFFSET_TRIM                    = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VREF_0P625_TRIM                          = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VREF_0P3125_TRIM                         = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IREF_GEN_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IPTAT_GEN_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VTEMP_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VTEMP_REF_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM9"
      sgroup "MBG1_MBG_TRIM9 (at 0x2cf9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VTEMP_BUF_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM10"
      sgroup "MBG1_MBG_TRIM10 (at 0x2cfa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IREF_TEMP_TRIM                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_MBG_TRIM11"
      sgroup "MBG1_MBG_TRIM11 (at 0x2cfb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG_TEMP_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM12"
      sgroup "MBG1_MBG_TRIM12 (at 0x2cfc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CC_GAIN_TRIM                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_MBG_TRIM13"
      sgroup "MBG1_MBG_TRIM13 (at 0x2cfd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CC_HI_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM14"
      sgroup "MBG1_MBG_TRIM14 (at 0x2cfe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CC_LO_TRIM                               = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS2"
      sgroup "MISC_STATUS2 (at 0x909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      sgroup "MISC_DTEST_DRV_CTL (at 0x943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_DRV_EN                             = "
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      sgroup "MISC_DTEST_DRV_VAL (at 0x944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_VAL                                = "
    tree.end
    tree "MISC_MISC_CTL1"
      sgroup "MISC_MISC_CTL1 (at 0x946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MISC_CTL                                 = "
    tree.end
    tree "MISC_TX_GTR_THRES_CTL"
      sgroup "MISC_TX_GTR_THRES_CTL (at 0x94a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TX_GTR_THRES_REG                         = " "0 (TRANSMIT_OVER),1 (GSM_TRANSMIT)"
    tree.end
    tree "MISC_PD_PHY_INT_MUX_SEL"
      sgroup "MISC_PD_PHY_INT_MUX_SEL (at 0x94b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MUX_SEL                                  = " "0 (INT_PD_PHY_0),1 (INT_PD_PHY_1),2 (INT_PD_PHY_2),3 (INT_PD_PHY_3),4 (INT_PD_PHY_4),5 (INT_PD_PHY_5),6 (INT_PD_PHY_6),7 (INT_PD_PHY_7)"
    tree.end
    tree "MISC_ANA_BUF1_EN_CTL"
      sgroup "MISC_ANA_BUF1_EN_CTL (at 0x980)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_ANA_BUF2_EN_CTL"
      sgroup "MISC_ANA_BUF2_EN_CTL (at 0x981)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_ANA_BUF3_EN_CTL"
      sgroup "MISC_ANA_BUF3_EN_CTL (at 0x982)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_ANA_BUF4_EN_CTL"
      sgroup "MISC_ANA_BUF4_EN_CTL (at 0x983)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (TEST_ACCESS_DISABLED),1 (TEST_ACCESS_ENABLED)"
    tree.end
    tree "MISC_ANA_IN1_SEL"
      sgroup "MISC_ANA_IN1_SEL (at 0x9e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ANA_IN2_SEL"
      sgroup "MISC_ANA_IN2_SEL (at 0x9e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ANA_IN3_SEL"
      sgroup "MISC_ANA_IN3_SEL (at 0x9e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ANA_IN4_SEL"
      sgroup "MISC_ANA_IN4_SEL (at 0x9e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ADC_PREMUX_SEL"
      sgroup "MISC_ADC_PREMUX_SEL (at 0x9e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_PREMUX_EN                            = " "0 (ATEST_MUX_DISABLED),1 (ATEST_MUX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_LV_MV_SEL                          = " "0 (ATEST_LV),1 (ATEST_MV)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_LINE_SEL                           = " "0 (ATEST1_XV),1 (ATEST2_XV),2 (ATEST3_XV),3 (ATEST4_XV)"
    tree.end
    tree "MISC_VDD_OK_CTL"
      sgroup "MISC_VDD_OK_CTL (at 0x9e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IGNORE_PRECISE                           = " "0, 1"
    tree.end
    tree "MISC_ANA_OUT1_SEL"
      sgroup "MISC_ANA_OUT1_SEL (at 0x9e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "MISC_ANA_OUT2_SEL"
      sgroup "MISC_ANA_OUT2_SEL (at 0x9ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "MISC_ANA_OUT3_SEL"
      sgroup "MISC_ANA_OUT3_SEL (at 0x9eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST5),1 (ATEST6),2 (ATEST7),3 (ATEST8)"
    tree.end
    tree "MISC_ANA_OUT4_SEL"
      sgroup "MISC_ANA_OUT4_SEL (at 0x9ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST5),1 (ATEST6),2 (ATEST7),3 (ATEST8)"
    tree.end
    tree "MISC_BIST_TEST"
      sgroup "MISC_BIST_TEST (at 0x9ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BIST_TEST_EN                             = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "MISC_CSIR_7_0"
      sgroup "MISC_CSIR_7_0 (at 0x9f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CSIR_7_0                                 = "
    tree.end
    tree "MISC_CSIR_15_8"
      sgroup "MISC_CSIR_15_8 (at 0x9f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CSIR_15_8                                = "
    tree.end
    tree "MISC_TRIM_ERROR_RC19P2_CLK"
      sgroup "MISC_TRIM_ERROR_RC19P2_CLK (at 0x9f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ERROR_SIGN                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_MAG                                = "
    tree.end
  tree.end
tree.end
tree "MVFLASH1"
  tree "MVFLASH1"
    tree "MVFLASH1_REVISION1"
      sgroup "MVFLASH1_REVISION1 (at 0x1d300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MVFLASH1_REVISION2"
      sgroup "MVFLASH1_REVISION2 (at 0x1d301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MVFLASH1_REVISION3"
      sgroup "MVFLASH1_REVISION3 (at 0x1d302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MVFLASH1_REVISION4"
      sgroup "MVFLASH1_REVISION4 (at 0x1d303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MVFLASH1_PERPH_TYPE"
      sgroup "MVFLASH1_PERPH_TYPE (at 0x1d304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MVFLASH1_PERPH_SUBTYPE"
      sgroup "MVFLASH1_PERPH_SUBTYPE (at 0x1d305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MVFLASH1_LED_STATUS1"
      sgroup "MVFLASH1_LED_STATUS1 (at 0x1d308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LED3_SHORT_FAULT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED2_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED2_SHORT_FAULT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED1_OPEN_FAULT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_SHORT_FAULT                         = " "0, 1"
    tree.end
    tree "MVFLASH1_LED_STATUS2"
      sgroup "MVFLASH1_LED_STATUS2 (at 0x1d309)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BCL                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BOB_S2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BOB_S1                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_DROOP                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   THERMAL_BOB_OVERLOAD                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   THERMAL_OTST3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   THERMAL_OTST2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERMAL_OTST1                            = " "0, 1"
    tree.end
    tree "MVFLASH1_LED_STATUS3"
      sgroup "MVFLASH1_LED_STATUS3 (at 0x1d30a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BOB_VOUT_RB                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MBG_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_VREG_READY_FAULT                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LED2_VREG_READY_FAULT                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LED1_VREG_READY_FAULT                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED3_TIMER_EXPIRE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_TIMER_EXPIRE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_TIMER_EXPIRE                        = " "0, 1"
    tree.end
    tree "MVFLASH1_LED1_IRAMP_STATUS"
      sgroup "MVFLASH1_LED1_IRAMP_STATUS (at 0x1d30b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IRAMP_CURRENT                            = "
    tree.end
    tree "MVFLASH1_LED2_IRAMP_STATUS"
      sgroup "MVFLASH1_LED2_IRAMP_STATUS (at 0x1d30c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IRAMP_CURRENT                            = "
    tree.end
    tree "MVFLASH1_LED3_IRAMP_STATUS"
      sgroup "MVFLASH1_LED3_IRAMP_STATUS (at 0x1d30d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d30d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd30d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IRAMP_CURRENT                            = "
    tree.end
    tree "MVFLASH1_INT_RT_STS"
      sgroup "MVFLASH1_INT_RT_STS (at 0x1d310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_RT_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_RT_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_RT_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_RT_STS                         = " "0, 1"
    tree.end
    tree "MVFLASH1_INT_SET_TYPE"
      sgroup "MVFLASH1_INT_SET_TYPE (at 0x1d311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_TYPE                          = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "MVFLASH1_INT_POLARITY_HIGH"
      sgroup "MVFLASH1_INT_POLARITY_HIGH (at 0x1d312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_HIGH                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "MVFLASH1_INT_POLARITY_LOW"
      sgroup "MVFLASH1_INT_POLARITY_LOW (at 0x1d313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_LOW                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "MVFLASH1_INT_LATCHED_CLR"
      sgroup "MVFLASH1_INT_LATCHED_CLR (at 0x1d314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_LATCHED_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_LATCHED_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_LATCHED_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "MVFLASH1_INT_EN_SET"
      sgroup "MVFLASH1_INT_EN_SET (at 0x1d315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_EN_SET               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_EN_SET               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MVFLASH1_INT_EN_CLR"
      sgroup "MVFLASH1_INT_EN_CLR (at 0x1d316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_EN_CLR               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_EN_CLR               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "MVFLASH1_INT_LATCHED_STS"
      sgroup "MVFLASH1_INT_LATCHED_STS (at 0x1d318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_LATCHED_STS          = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_LATCHED_STS          = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "MVFLASH1_INT_PENDING_STS"
      sgroup "MVFLASH1_INT_PENDING_STS (at 0x1d319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE_PENDING_STS          = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE_PENDING_STS          = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "MVFLASH1_INT_MID_SEL"
      sgroup "MVFLASH1_INT_MID_SEL (at 0x1d31a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "MVFLASH1_INT_PRIORITY"
      sgroup "MVFLASH1_INT_PRIORITY (at 0x1d31b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "MVFLASH1_LED1_SAFETY_TIMER"
      sgroup "MVFLASH1_LED1_SAFETY_TIMER (at 0x1d340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_ENA                                = " "0 (TIMER_DISA),1 (TIMER_ENA)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SAFETY_TIMER                             = "
    tree.end
    tree "MVFLASH1_LED2_SAFETY_TIMER"
      sgroup "MVFLASH1_LED2_SAFETY_TIMER (at 0x1d341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_ENA                                = " "0 (TIMER_DISA),1 (TIMER_ENA)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SAFETY_TIMER                             = "
    tree.end
    tree "MVFLASH1_LED3_SAFETY_TIMER"
      sgroup "MVFLASH1_LED3_SAFETY_TIMER (at 0x1d342)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_ENA                                = " "0 (TIMER_DISA),1 (TIMER_ENA)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SAFETY_TIMER                             = "
    tree.end
    tree "MVFLASH1_LED1_ITARGET"
      sgroup "MVFLASH1_LED1_ITARGET (at 0x1d343)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ITARGET_CURRENT                          = "
    tree.end
    tree "MVFLASH1_LED2_ITARGET"
      sgroup "MVFLASH1_LED2_ITARGET (at 0x1d344)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ITARGET_CURRENT                          = "
    tree.end
    tree "MVFLASH1_LED3_ITARGET"
      sgroup "MVFLASH1_LED3_ITARGET (at 0x1d345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ITARGET_CURRENT                          = "
    tree.end
    tree "MVFLASH1_ENABLE_CONTROL"
      sgroup "MVFLASH1_ENABLE_CONTROL (at 0x1d346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_ENABLE                            = " "0 (MOD_DISA),1 (MOD_ENA)"
    tree.end
    tree "MVFLASH1_LED_IRESOLUTION"
      sgroup "MVFLASH1_LED_IRESOLUTION (at 0x1d347)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LED3_RESOLUTION                          = " "0 (IRES_12P5MA),1 (IRES_10P0MA),2 (IRES_7P5MA),3 (IRES_5P0MA)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LED2_RESOLUTION                          = " "0 (IRES_12P5MA),1 (IRES_10P0MA),2 (IRES_7P5MA),3 (IRES_5P0MA)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED1_RESOLUTION                          = " "0 (IRES_12P5MA),1 (IRES_10P0MA),2 (IRES_7P5MA),3 (IRES_5P0MA)"
    tree.end
    tree "MVFLASH1_STROBE_CFG"
      sgroup "MVFLASH1_STROBE_CFG (at 0x1d348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STROBE_VS_MASK                           = " "0 (STROBE_OPTION1),1 (STROBE_OPTION2),2 (STROBE_OPTION3),3 (UNUSED_OPTION)"
    tree.end
    tree "MVFLASH1_LED1_STROBE_CTRL"
      sgroup "MVFLASH1_LED1_STROBE_CTRL (at 0x1d349)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HW_SW_STROBE_SEL                         = " "0 (STROBE_SW),1 (STROBE_HW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_STROBE_TRIGGER                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_STROBE_POLARITY                       = " "0 (ACTIVE_LOW),1 (ACTIVE_HIGH)"
    tree.end
    tree "MVFLASH1_LED2_STROBE_CTRL"
      sgroup "MVFLASH1_LED2_STROBE_CTRL (at 0x1d34a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HW_SW_STROBE_SEL                         = " "0 (STROBE_SW),1 (STROBE_HW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_STROBE_TRIGGER                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_STROBE_POLARITY                       = " "0 (ACTIVE_LOW),1 (ACTIVE_HIGH)"
    tree.end
    tree "MVFLASH1_LED3_STROBE_CTRL"
      sgroup "MVFLASH1_LED3_STROBE_CTRL (at 0x1d34b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HW_SW_STROBE_SEL                         = " "0 (STROBE_SW),1 (STROBE_HW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_STROBE_TRIGGER                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_STROBE_POLARITY                       = " "0 (ACTIVE_LOW),1 (ACTIVE_HIGH)"
    tree.end
    tree "MVFLASH1_EN_LED_CTRL"
      sgroup "MVFLASH1_EN_LED_CTRL (at 0x1d34c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_LED3                                  = " "0 (LED3_DISA),1 (LED3_ENA)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_LED2                                  = " "0 (LED2_DISA),1 (LED2_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_LED1                                  = " "0 (LED1_DISA),1 (LED1_ENA)"
    tree.end
    tree "MVFLASH1_LED1_HDRM_PRGM"
      sgroup "MVFLASH1_LED1_HDRM_PRGM (at 0x1d34d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VOLTAGE                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HI_LO_WIN                                = "
    tree.end
    tree "MVFLASH1_LED2_HDRM_PRGM"
      sgroup "MVFLASH1_LED2_HDRM_PRGM (at 0x1d34e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VOLTAGE                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HI_LO_WIN                                = "
    tree.end
    tree "MVFLASH1_LED3_HDRM_PRGM"
      sgroup "MVFLASH1_LED3_HDRM_PRGM (at 0x1d34f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d34f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd34f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VOLTAGE                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HI_LO_WIN                                = "
    tree.end
    tree "MVFLASH1_LED_HDRM_AUTO_MODE"
      sgroup "MVFLASH1_LED_HDRM_AUTO_MODE (at 0x1d350)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LED3_AUTO_MODE                           = " "0 (LED3_AUTOMODE_DISA),1 (LED3_AUTOMODE_ENA)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED2_AUTO_MODE                           = " "0 (LED2_AUTOMODE_DISA),1 (LED2_AUTOMODE_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1_AUTO_MODE                           = " "0 (LED1_AUTOMODE_DISA),1 (LED1_AUTOMODE_ENA)"
    tree.end
    tree "MVFLASH1_WARMUP_DELAY"
      sgroup "MVFLASH1_WARMUP_DELAY (at 0x1d351)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DELAY                                    = " "0 (WARMUP_DLY_32US),1 (WARMUP_DLY_64US),2 (WARMUP_DLY_128US),3 (WARMUP_DLY_192US)"
    tree.end
    tree "MVFLASH1_ISC_DELAY"
      sgroup "MVFLASH1_ISC_DELAY (at 0x1d352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DELAY                                    = " "0 (ISC_DLY_32US),1 (ISC_DLY_64US),2 (ISC_DLY_128US),3 (ISC_DLY_192US)"
    tree.end
    tree "MVFLASH1_THERMAL_RAMP_DN_RATE"
      sgroup "MVFLASH1_THERMAL_RAMP_DN_RATE (at 0x1d355)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OTST1_RAMP_CTRL                          = " "0 (NOT_RAMP_BACKUP),1 (RAMP_BACKUP)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   THERMAL_DERATE_SLOW                      = " "0 (THERM_RAMPDN_SLOW_128US),1 (THERM_RAMPDN_SLOW_256US),2 (THERM_RAMPDN_SLOW_512US),3 (THERM_RAMPDN_SLOW_1024US),4 (THERM_RAMPDN_SLOW_2048US),5 (THERM_RAMPDN_SLOW_4096US),6 (THERM_RAMPDN_SLOW_8192US),7 (THERM_RAMPDN_SLOW_314592US)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   THERMAL_DERATE_FAST                      = " "0 (THERM_RAMPDN_FAST_32US),1 (THERM_RAMPDN_FAST_64US),2 (THERM_RAMPDN_FAST_96US),3 (THERM_RAMPDN_FAST_128US),4 (THERM_RAMPDN_FAST_256US),5 (THERM_RAMPDN_FAST_384US),6 (THERM_RAMPDN_FAST_512US),7 (THERM_RAMPDN_FAST_UNUSED)"
    tree.end
    tree "MVFLASH1_THERMAL_THRSH1"
      sgroup "MVFLASH1_THERMAL_THRSH1 (at 0x1d356)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   THRESHOLD                                = " "0 (THERM_DERATE_THRSHLD_85C),1 (THERM_DERATE_THRSHLD_79C),2 (THERM_DERATE_THRSHLD_73C),3 (THERM_DERATE_THRSHLD_67C),4 (THERM_DERATE_THRSHLD_109C),5 (THERM_DERATE_THRSHLD_103C),6 (THERM_DERATE_THRSHLD_97C),7 (THERM_DERATE_THRSHLD_91C)"
    tree.end
    tree "MVFLASH1_THERMAL_THRSH2"
      sgroup "MVFLASH1_THERMAL_THRSH2 (at 0x1d357)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   THRESHOLD                                = " "0 (THERM_DERATE_THRSHLD_110C),1 (THERM_DERATE_THRSHLD_104C),2 (THERM_DERATE_THRSHLD_98C),3 (THERM_DERATE_THRSHLD_92C),4 (THERM_DERATE_THRSHLD_134C),5 (THERM_DERATE_THRSHLD_128C),6 (THERM_DERATE_THRSHLD_122C),7 (THERM_DERATE_THRSHLD_116C)"
    tree.end
    tree "MVFLASH1_THERMAL_THRSH3"
      sgroup "MVFLASH1_THERMAL_THRSH3 (at 0x1d358)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   THRESHOLD                                = " "0 (THERM_DERATE_THRSHLD_125C),1 (THERM_DERATE_THRSHLD_119C),2 (THERM_DERATE_THRSHLD_113C),3 (THERM_DERATE_THRSHLD_107C),4 (THERM_DERATE_THRSHLD_149C),5 (THERM_DERATE_THRSHLD_143C),6 (THERM_DERATE_THRSHLD_137C),7 (THERM_DERATE_THRSHLD_131C)"
    tree.end
    tree "MVFLASH1_THERMAL_HYSTERESIS"
      sgroup "MVFLASH1_THERMAL_HYSTERESIS (at 0x1d359)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DERATE_HYS                               = " "0 (THERM_DERATE_HYST_0C),1 (THERM_DERATE_HYST_1P5C),2 (THERM_DERATE_HYST_3C),3 (THERM_DERATE_HYST_4P5C)"
    tree.end
    tree "MVFLASH1_THERMAL_DEBOUNCE"
      sgroup "MVFLASH1_THERMAL_DEBOUNCE (at 0x1d35a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME                            = " "0 (THERM_DEBOUNCE_0US),1 (THERM_DEBOUNCE_16US),2 (THERM_DEBOUNCE_32US),3 (THERM_DEBOUNCE_64US)"
    tree.end
    tree "MVFLASH1_RGLR_RAMP_RATE"
      sgroup "MVFLASH1_RGLR_RAMP_RATE (at 0x1d35b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   RAMP_UP_STEP                             = " "0 (RAMP_UP_STEP_0P2US),1 (RAMP_UP_STEP_0P4US),2 (RAMP_UP_STEP_0P8US),3 (RAMP_UP_STEP_1P6US),4 (RAMP_UP_STEP_3P2US),5 (RAMP_UP_STEP_6P4US),6 (RAMP_UP_STEP_12P8US),7 (RAMP_UP_STEP_25P6US)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_DN_STEP                             = " "0 (RAMP_DN_STEP_0P2US),1 (RAMP_DN_STEP_0P4US),2 (RAMP_DN_STEP_0P8US),3 (RAMP_DN_STEP_1P6US),4 (RAMP_DN_STEP_3P2US),5 (RAMP_DN_STEP_6P4US),6 (RAMP_DN_STEP_12P8US),7 (RAMP_DN_STEP_25P6US)"
    tree.end
    tree "MVFLASH1_ALT_RAMP_DN_RATE"
      sgroup "MVFLASH1_ALT_RAMP_DN_RATE (at 0x1d35c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ALTERNATE_DN_STEP                        = " "0 (ALT_RMP_DWN_0P2US),1 (ALT_RMP_DWN_0P4US),2 (ALT_RMP_DWN_0P8US),3 (ALT_RMP_DWN_1P6US)"
    tree.end
    tree "MVFLASH1_STROBE_DEBOUNCE"
      sgroup "MVFLASH1_STROBE_DEBOUNCE (at 0x1d35d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME                            = " "0 (STROBE_DEBOUNCE_0US),1 (STROBE_DEBOUNCE_8US),2 (STROBE_DEBOUNCE_16US),3 (STROBE_DEBOUNCE_26US)"
    tree.end
    tree "MVFLASH1_MASK_DEBOUNCE"
      sgroup "MVFLASH1_MASK_DEBOUNCE (at 0x1d35e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEBOUNCE_TIME_TX                         = " "0 (MASK_DEBOUNCE_0US),1 (MASK_DEBOUNCE_8US),2 (MASK_DEBOUNCE_16US),3 (MASK_DEBOUNCE_26US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME_GP                         = " "0 (MASK_DEBOUNCE_0US),1 (MASK_DEBOUNCE_8US),2 (MASK_DEBOUNCE_16US),3 (MASK_DEBOUNCE_26US)"
    tree.end
    tree "MVFLASH1_FAULT_DEBOUNCE"
      sgroup "MVFLASH1_FAULT_DEBOUNCE (at 0x1d35f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d35f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd35f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME                            = " "0 (FAULT_DEBOUNCE_0US),1 (FAULT_DEBOUNCE_0P1US),2 (FAULT_DEBOUNCE_1P0US),3 (FAULT_DEBOUNCE_3P2US)"
    tree.end
    tree "MVFLASH1_VPH_DROOP_CFG"
      sgroup "MVFLASH1_VPH_DROOP_CFG (at 0x1d360)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RATE_SEL                                 = " "0 (REGULAR_RATE),1 (ALTERNATE_RATE)"
    tree.end
    tree "MVFLASH1_VPH_DROOP_THRESHOLD"
      sgroup "MVFLASH1_VPH_DROOP_THRESHOLD (at 0x1d361)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DROOP_HYS                                = " "0 (VDIP_HYST_0MV),1 (VDIP_HYST_25MV),2 (VDIP_HYST_50MV),3 (VDIP_HYST_75MV)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DROOP_THRESHOLD                          = " "0 (VDIP_THRES_2P5V),1 (VDIP_THRES_2P6V),2 (VDIP_THRES_2P7V),3 (VDIP_THRES_2P8V),4 (VDIP_THRES_2P9V),5 (VDIP_THRES_3V),6 (VDIP_THRES_3P1V),7 (VDIP_THRES_3P2V)"
    tree.end
    tree "MVFLASH1_VPH_DROOP_DEBOUNCE"
      sgroup "MVFLASH1_VPH_DROOP_DEBOUNCE (at 0x1d362)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME                            = " "0 (DROOP_DEBOUNCE_0US),1 (DROOP_DEBOUNCE_8US),2 (DROOP_DEBOUNCE_16US),3 (DROOP_DEBOUNCE_26US)"
    tree.end
    tree "MVFLASH1_BCL_CFG"
      sgroup "MVFLASH1_BCL_CFG (at 0x1d363)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RATE_SEL                                 = " "0 (REGULAR_RATE),1 (ALTERNATE_RATE)"
    tree.end
    tree "MVFLASH1_MASK_TX_CFG"
      sgroup "MVFLASH1_MASK_TX_CFG (at 0x1d364)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLAMP_SEL                                = " "0 (LOW_CLAMP_LEVEL),1 (MID_CLAMP_LEVEL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_CTRL                                = " "0 (NOT_RAMP_BACKUP),1 (RAMP_BACKUP)"
    tree.end
    tree "MVFLASH1_MASK_GP_CFG"
      sgroup "MVFLASH1_MASK_GP_CFG (at 0x1d365)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RATE_SEL                                 = " "0 (REGULAR_RATE),1 (ALTERNATE_RATE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLAMP_SEL                                = " "0 (LOW_CLAMP_LEVEL),1 (MID_CLAMP_LEVEL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_CTRL                                = " "0 (NOT_RAMP_BACKUP),1 (RAMP_BACKUP)"
    tree.end
    tree "MVFLASH1_BOB_ILIMIT_CFG"
      sgroup "MVFLASH1_BOB_ILIMIT_CFG (at 0x1d366)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RATE_SEL                                 = " "0 (REGULAR_RATE),1 (ALTERNATE_RATE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_CTRL                                = " "0 (NOT_RAMP_BACKUP),1 (RAMP_BACKUP)"
    tree.end
    tree "MVFLASH1_ILED_GRT_THRESHOLD"
      sgroup "MVFLASH1_ILED_GRT_THRESHOLD (at 0x1d367)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ILED_THRESHOLD                           = "
    tree.end
    tree "MVFLASH1_LED1N2_MITIGATION_ICLAMP_LOW"
      sgroup "MVFLASH1_LED1N2_MITIGATION_ICLAMP_LOW (at 0x1d368)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CLAMP_LEVEL                              = "
    tree.end
    tree "MVFLASH1_LED1N2_MITIGATION_ICLAMP_MID"
      sgroup "MVFLASH1_LED1N2_MITIGATION_ICLAMP_MID (at 0x1d369)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CLAMP_LEVEL                              = "
    tree.end
    tree "MVFLASH1_LED3_MITIGATION_ICLAMP_LOW"
      sgroup "MVFLASH1_LED3_MITIGATION_ICLAMP_LOW (at 0x1d36a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d36a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd36a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CLAMP_LEVEL                              = "
    tree.end
    tree "MVFLASH1_LED3_MITIGATION_ICLAMP_MID"
      sgroup "MVFLASH1_LED3_MITIGATION_ICLAMP_MID (at 0x1d36b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d36b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd36b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   CLAMP_LEVEL                              = "
    tree.end
    tree "MVFLASH1_HDRM_SENSE_DEBOUNCE"
      sgroup "MVFLASH1_HDRM_SENSE_DEBOUNCE (at 0x1d36c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d36c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd36c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEBOUNCE_SNS_HI_TIME                     = " "0 (SNSHI_DEBOUNCE_0US),1 (SNSHI_DEBOUNCE_1US),2 (SNSHI_DEBOUNCE_2US),3 (SNSHI_DEBOUNCE_4US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_SNS_LO_TIME                     = " "0 (SNSLO_DEBOUNCE_0US),1 (SNSLO_DEBOUNCE_1US),2 (SNSLO_DEBOUNCE_2US),3 (SNSLO_DEBOUNCE_4US)"
    tree.end
    tree "MVFLASH1_VG_GRT_2VT_DEBOUNCE"
      sgroup "MVFLASH1_VG_GRT_2VT_DEBOUNCE (at 0x1d36d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d36d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd36d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEBOUNCE_TIME                            = " "0 (VGS_DEBOUNCE_0US),1 (VGS_DEBOUNCE_1US),2 (VGS_DEBOUNCE_2US),3 (VGS_DEBOUNCE_4US)"
    tree.end
    tree "MVFLASH1_MITIGATION_SEL"
      sgroup "MVFLASH1_MITIGATION_SEL (at 0x1d36e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d36e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd36e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHARGER                                  = " "0 (MITIGATION_DISA),1 (MITIGATION_BY_ILED_THRSHLD),2 (MITIGATION_BY_SW),3 (MITIGATION_UNUSED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PREEMPTIVE_LMH                           = " "0 (MITIGATION_DISA),1 (MITIGATION_BY_ILED_THRSHLD),2 (MITIGATION_BY_SW),3 (MITIGATION_UNUSED)"
    tree.end
    tree "MVFLASH1_MITIGATION_SW"
      sgroup "MVFLASH1_MITIGATION_SW (at 0x1d36f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d36f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd36f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHARGER                                  = " "0 (SW_MITIGATION_DISA),1 (SW_MITIGATION_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PREEMPTIVE_LMH                           = " "0 (SW_MITIGATION_DISA),1 (SW_MITIGATION_ENA)"
    tree.end
    tree "MVFLASH1_PREEMPTIVE_LMH_LEVEL"
      sgroup "MVFLASH1_PREEMPTIVE_LMH_LEVEL (at 0x1d370)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LMH_LEVEL                                = " "0 (LMH_LVL_ZERO),1 (LMH_LVL_ONE),2 (LMH_LVL_UNUSED),3 (LMH_LVL_TWO)"
    tree.end
    tree "MVFLASH1_MULTI_STROBE_CTRL"
      sgroup "MVFLASH1_MULTI_STROBE_CTRL (at 0x1d371)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LED3_FLASH_ONCE_ONLY                     = " "0 (MULTI_STROBE),1 (SINGLE_STROBE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED1N2_FLASH_ONCE_ONLY                   = " "0 (MULTI_STROBE),1 (SINGLE_STROBE)"
    tree.end
    tree "MVFLASH1_LPG_INPUT_CTRL"
      sgroup "MVFLASH1_LPG_INPUT_CTRL (at 0x1d372)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPG_INPUT_SEL                            = " "0 (LPG_AS_STROBE_DISA),1 (LGP_AS_STROBE_ENA)"
    tree.end
    tree "MVFLASH1_LED1_IDESTROBE_VAL"
      sgroup "MVFLASH1_LED1_IDESTROBE_VAL (at 0x1d373)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DESTROBE_CURRENT                         = "
    tree.end
    tree "MVFLASH1_LED2_IDESTROBE_VAL"
      sgroup "MVFLASH1_LED2_IDESTROBE_VAL (at 0x1d374)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DESTROBE_CURRENT                         = "
    tree.end
    tree "MVFLASH1_LED3_IDESTROBE_VAL"
      sgroup "MVFLASH1_LED3_IDESTROBE_VAL (at 0x1d375)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   DESTROBE_CURRENT                         = "
    tree.end
    tree "MVFLASH1_CURRENT_DERATE_EN"
      sgroup "MVFLASH1_CURRENT_DERATE_EN (at 0x1d376)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SHORT_DRIVE_GATE                         = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GP_MASK_EN                               = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TX_MASK_EN                               = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BOB_ILIM_EN                              = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_EN                                   = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VPH_DROOP_EN                             = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OPEN_DET_EN                              = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SHORT_DET_EN                             = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
    tree.end
    tree "MVFLASH1_THERMAL_DERATE_EN"
      sgroup "MVFLASH1_THERMAL_DERATE_EN (at 0x1d377)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_BOB_THERM                             = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_OTST3_THERM                           = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_OTST2_THERM                           = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_OTST1_THERM                           = " "0 (TRIGGER_DISA),1 (TRIGGER_ENA)"
    tree.end
    tree "MVFLASH1_SEC_ACCESS"
      sgroup "MVFLASH1_SEC_ACCESS (at 0x1d3d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MVFLASH1_PERPH_RESET_CTL2"
      sgroup "MVFLASH1_PERPH_RESET_CTL2 (at 0x1d3d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "MVFLASH1_PERPH_RESET_CTL3"
      sgroup "MVFLASH1_PERPH_RESET_CTL3 (at 0x1d3da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "MVFLASH1_PERPH_RESET_CTL4"
      sgroup "MVFLASH1_PERPH_RESET_CTL4 (at 0x1d3db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "MVFLASH1_INT_TEST1"
      sgroup "MVFLASH1_INT_TEST1 (at 0x1d3e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "MVFLASH1_INT_TEST_VAL"
      sgroup "MVFLASH1_INT_TEST_VAL (at 0x1d3e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LED1_RMP_UP_DONE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LED2_RMP_UP_DONE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LED3_RMP_UP_DONE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALL_LED_RMP_UP_DONE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ALL_LED_RMP_DN_DONE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLSH_TIMER_EXP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MITIGATION                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LED_FAULT                                = " "0, 1"
    tree.end
    tree "MVFLASH1_TEST1"
      sgroup "MVFLASH1_TEST1 (at 0x1d3e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "MVFLASH1_TEST2"
      sgroup "MVFLASH1_TEST2 (at 0x1d3e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ATEST                                    = "
    tree.end
    tree "MVFLASH1_TEST3"
      sgroup "MVFLASH1_TEST3 (at 0x1d3e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BW_LO_CFG                                = " "0 (BW1_BW2_FOLLOW_HW),1 (BW1_ZERO_BW2_ZERO),2 (BW1_ONE_BW2_ZERO),3 (BW1_ONE_BW2_ONE)"
    tree.end
    tree "MVFLASH1_TEST4"
      sgroup "MVFLASH1_TEST4 (at 0x1d3e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   HDRM_AUTO_OFFSET_EN                      = " "0 (HDRM_OFFSET_DISA),1 (HDRM_OFFSET_OPT1),2 (HDRM_OFFSET_OPT2),3 (HDRM_OFFSET_UNUSED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VLED_PULL_DN                             = " "0 (NOT_PULLDN),1 (PULLDN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MAINAMP_LO_BW2_HI_OFFSET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK3                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MASK2                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MASK1                                    = " "0, 1"
    tree.end
    tree "MVFLASH1_TEST5"
      sgroup "MVFLASH1_TEST5 (at 0x1d3e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRIMMAINAMP_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIMVDSAMP_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VGS_GRT_2VT_EN                           = " "0 (DISA),1 (ENA)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HDRM_SNS_EN                              = " "0 (DISA),1 (ENA)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_TO_ADC_EN                           = " "0 (DISA),1 (ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_SNS_BIAS_EN                         = " "0 (DISA),1 (ENA)"
    tree.end
    tree "MVFLASH1_TEST6"
      sgroup "MVFLASH1_TEST6 (at 0x1d3e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_THERM_CLIP_ON_START                = " "0 (NOT_CLIP_AT_START),1 (CLIP_AT_START)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTST3_BOB_THERM_CLIP_ON_START            = " "0 (NOT_CLIP_AT_START),1 (CLIP_AT_START)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_S1_CLIP_ON_START                     = " "0 (NOT_CLIP_AT_START),1 (CLIP_AT_START)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BCL_CLIP_ON_START                        = " "0 (NOT_CLIP_AT_START),1 (CLIP_AT_START)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VPH_DROOP_CLIP_ON_START                  = " "0 (NOT_CLIP_AT_START),1 (CLIP_AT_START)"
    tree.end
    tree "MVFLASH1_TEST8"
      sgroup "MVFLASH1_TEST8 (at 0x1d3e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_VREG_READY                         = " "0 (NOT_FORCE_VREG_RDY),1 (FORCE_VREG_RDY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_VREG_READY                        = " "0 (NOT_FOLLOW_VREG_RDY),1 (FOLLOW_VREG_RDY)"
    tree.end
    tree "MVFLASH1_TIMER_DISA_MITIGATION_CLAMP"
      sgroup "MVFLASH1_TIMER_DISA_MITIGATION_CLAMP (at 0x1d3ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   SAFEGUARD_MITIGATION                     = "
    tree.end
    tree "MVFLASH1_TRIM_NUM"
      sgroup "MVFLASH1_TRIM_NUM (at 0x1d3f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "MVFLASH1_LED1_IREF_TRIM_LO"
      sgroup "MVFLASH1_LED1_IREF_TRIM_LO (at 0x1d3f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED2_IREF_TRIM_LO"
      sgroup "MVFLASH1_LED2_IREF_TRIM_LO (at 0x1d3f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED3_IREF_TRIM_LO"
      sgroup "MVFLASH1_LED3_IREF_TRIM_LO (at 0x1d3f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED1_IREF_TRIM_MID"
      sgroup "MVFLASH1_LED1_IREF_TRIM_MID (at 0x1d3f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED2_IREF_TRIM_MID"
      sgroup "MVFLASH1_LED2_IREF_TRIM_MID (at 0x1d3f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED3_IREF_TRIM_MID"
      sgroup "MVFLASH1_LED3_IREF_TRIM_MID (at 0x1d3f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED1_IREF_TRIM_HI"
      sgroup "MVFLASH1_LED1_IREF_TRIM_HI (at 0x1d3f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED2_IREF_TRIM_HI"
      sgroup "MVFLASH1_LED2_IREF_TRIM_HI (at 0x1d3f8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED3_IREF_TRIM_HI"
      sgroup "MVFLASH1_LED3_IREF_TRIM_HI (at 0x1d3f9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_TEMP_SNS_IBIAS_TRIM"
      sgroup "MVFLASH1_TEMP_SNS_IBIAS_TRIM (at 0x1d3fa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM                                     = "
    tree.end
    tree "MVFLASH1_LED1_PROCS_VDS_TRIM"
      sgroup "MVFLASH1_LED1_PROCS_VDS_TRIM (at 0x1d3fb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   PROCESS                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDS_AMP                                  = "
    tree.end
    tree "MVFLASH1_LED2_PROCS_VDS_TRIM"
      sgroup "MVFLASH1_LED2_PROCS_VDS_TRIM (at 0x1d3fc)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   PROCESS                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDS_AMP                                  = "
    tree.end
    tree "MVFLASH1_LED3_PROCS_VDS_TRIM"
      sgroup "MVFLASH1_LED3_PROCS_VDS_TRIM (at 0x1d3fd)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   PROCESS                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDS_AMP                                  = "
    tree.end
    tree "MVFLASH1_LED1N2_MAIN_AMP"
      sgroup "MVFLASH1_LED1N2_MAIN_AMP (at 0x1d3fe)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LED1_TRIM                                = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LED2_TRIM                                = "
    tree.end
    tree "MVFLASH1_LED3_MAIN_AMP"
      sgroup "MVFLASH1_LED3_MAIN_AMP (at 0x1d3ff)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        set &access:&cmd_addr %l 0x80d3ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd3ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM                                     = "
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_TRIG_LATCHED"
      sgroup "PBS_CLIENT0_TRIG_LATCHED (at 0x710a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80710a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x710a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_LAT                              = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_NUM_TRIGGERS"
      sgroup "PBS_CLIENT0_NUM_TRIGGERS (at 0x710f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80710f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x710f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIGGERS                             = "
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT0_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT0_HW_TRIG_RE_EN (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT0_HW_TRIG_FE_EN (at 0x7141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_LAT_SET                          = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT0_TRIG_LATCHED_CLR (at 0x7148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_LAT_CLR                          = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_SCRATCH1"
      sgroup "PBS_CLIENT0_SCRATCH1 (at 0x7150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT0_SCRATCH2"
      sgroup "PBS_CLIENT0_SCRATCH2 (at 0x7151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_TRIG_LATCHED"
      sgroup "PBS_CLIENT1_TRIG_LATCHED (at 0x720a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80720a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x720a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT                              = "
    tree.end
    tree "PBS_CLIENT1_NUM_TRIGGERS"
      sgroup "PBS_CLIENT1_NUM_TRIGGERS (at 0x720f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80720f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x720f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIGGERS                             = "
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT1_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT1_HW_TRIG_RE_EN (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_EN                               = "
    tree.end
    tree "PBS_CLIENT1_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT1_HW_TRIG_FE_EN (at 0x7241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_EN                               = "
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT_SET                          = "
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT1_TRIG_LATCHED_CLR (at 0x7248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT_CLR                          = "
    tree.end
    tree "PBS_CLIENT1_SCRATCH1"
      sgroup "PBS_CLIENT1_SCRATCH1 (at 0x7250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT1_SCRATCH2"
      sgroup "PBS_CLIENT1_SCRATCH2 (at 0x7251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "PBS_CLIENT1_CHAN_SEL_0"
      sgroup "PBS_CLIENT1_CHAN_SEL_0 (at 0x72e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_TRIG_EN                            = " "0 (DTEST_TRIGGER_OFF),1 (DTEST_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_TRIG_SEL                           = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_TRIG_LATCHED"
      sgroup "PBS_CLIENT2_TRIG_LATCHED (at 0x730a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80730a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x730a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT                              = "
    tree.end
    tree "PBS_CLIENT2_NUM_TRIGGERS"
      sgroup "PBS_CLIENT2_NUM_TRIGGERS (at 0x730f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80730f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x730f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIGGERS                             = "
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT2_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT2_HW_TRIG_RE_EN (at 0x7340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_EN                               = "
    tree.end
    tree "PBS_CLIENT2_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT2_HW_TRIG_FE_EN (at 0x7341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_EN                               = "
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT_SET                          = "
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT2_TRIG_LATCHED_CLR (at 0x7348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT_CLR                          = "
    tree.end
    tree "PBS_CLIENT2_SCRATCH1"
      sgroup "PBS_CLIENT2_SCRATCH1 (at 0x7350)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT2_SCRATCH2"
      sgroup "PBS_CLIENT2_SCRATCH2 (at 0x7351)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "PBS_CLIENT2_CHAN_SEL_0"
      sgroup "PBS_CLIENT2_CHAN_SEL_0 (at 0x73e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_TRIG_EN                            = " "0 (DTEST_TRIGGER_OFF),1 (DTEST_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_TRIG_SEL                           = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_TRIG_LATCHED"
      sgroup "PBS_CLIENT3_TRIG_LATCHED (at 0x740a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80740a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x740a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT                              = "
    tree.end
    tree "PBS_CLIENT3_NUM_TRIGGERS"
      sgroup "PBS_CLIENT3_NUM_TRIGGERS (at 0x740f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80740f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x740f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIGGERS                             = "
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT3_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT3_HW_TRIG_RE_EN (at 0x7440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_EN                               = "
    tree.end
    tree "PBS_CLIENT3_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT3_HW_TRIG_FE_EN (at 0x7441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_EN                               = "
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT_SET                          = "
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT3_TRIG_LATCHED_CLR (at 0x7448)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIGGER_LAT_CLR                          = "
    tree.end
    tree "PBS_CLIENT3_SCRATCH1"
      sgroup "PBS_CLIENT3_SCRATCH1 (at 0x7450)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT3_SCRATCH2"
      sgroup "PBS_CLIENT3_SCRATCH2 (at 0x7451)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "PBS_CLIENT3_CHAN_SEL_0"
      sgroup "PBS_CLIENT3_CHAN_SEL_0 (at 0x74e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_TRIG_EN                            = " "0 (DTEST_TRIGGER_OFF),1 (DTEST_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_TRIG_SEL                           = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_NUM_CLIENTS"
      sgroup "PBS_CORE_NUM_CLIENTS (at 0x7007)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_CLIENTS                              = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_NUM_TRIGCL"
      sgroup "PBS_CORE_NUM_TRIGCL (at 0x7009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIGCL                               = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_LSB_0"
      sgroup "PBS_CORE_TRIG_START_ADDR_LSB_0 (at 0x7050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_LSB_1"
      sgroup "PBS_CORE_TRIG_START_ADDR_LSB_1 (at 0x7054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_LSB_2"
      sgroup "PBS_CORE_TRIG_START_ADDR_LSB_2 (at 0x7058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_LSB_3"
      sgroup "PBS_CORE_TRIG_START_ADDR_LSB_3 (at 0x705c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_MSB_0"
      sgroup "PBS_CORE_TRIG_START_ADDR_MSB_0 (at 0x7051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_MSB_1"
      sgroup "PBS_CORE_TRIG_START_ADDR_MSB_1 (at 0x7055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_MSB_2"
      sgroup "PBS_CORE_TRIG_START_ADDR_MSB_2 (at 0x7059)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG_START_ADDR_MSB_3"
      sgroup "PBS_CORE_TRIG_START_ADDR_MSB_3 (at 0x705d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_TRIG_STATUS0"
      sgroup "PBS_CORE_TRIG_STATUS0 (at 0x7098)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_TRIG_COMP                           = "
    tree.end
    tree "PBS_CORE_TRIG_STATUS1"
      sgroup "PBS_CORE_TRIG_STATUS1 (at 0x7099)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_TRIG_NORMAL                         = "
    tree.end
    tree "PBS_CORE_TRIG_STATUS2"
      sgroup "PBS_CORE_TRIG_STATUS2 (at 0x709a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80709a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x709a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_IN_SERVICE                          = "
    tree.end
    tree "PBS_CORE_TRIG_STATUS3"
      sgroup "PBS_CORE_TRIG_STATUS3 (at 0x709b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80709b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x709b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_TRIG_ERROR                          = "
    tree.end
    tree "PBS_CORE_TRIG_STATUS4"
      sgroup "PBS_CORE_TRIG_STATUS4 (at 0x709c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80709c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x709c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_TRIG_ABORTED                        = "
    tree.end
    tree "PBS_CORE_RAM_CFG1"
      sgroup "PBS_CORE_RAM_CFG1 (at 0x70a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_RAM_CFG2"
      sgroup "PBS_CORE_RAM_CFG2 (at 0x70a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MTYPE                                    = " "0 (RAM18U),1 (RAM65N)"
    tree.end
    tree "PBS_CORE_NVM_CFG1"
      sgroup "PBS_CORE_NVM_CFG1 (at 0x70a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_NVM_CFG2"
      sgroup "PBS_CORE_NVM_CFG2 (at 0x70a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MTYPE                                    = " "0 (EMEMORY),1 (KILOPASS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPE                                     = " "0 (OTP),1 (ROM)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACCESS                                   = " "0 (WRITE_1200US_READ_800NS_INSTR_PR_1510NS),1 (WRITE_600US_READ_400NS_INSTR_PR_940NS),2 (WRITE_300US_READ_200NS_INSTR_PR_730NS),3 (reserved)"
    tree.end
    tree "PBS_CORE_PARAM_SETTINGS"
      sgroup "PBS_CORE_PARAM_SETTINGS (at 0x70a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_PBS                                 = " "0 (REGULAR_PBS),1 (FAST_PBS_ON)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   NUM_MACHINE_REGS                         = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEBUG_DTEST                              = " "0 (DEBUG_NEXT_CMD),1 (DEBUG_NEXT_DTEST)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0 (DEBUG_NEXT_NOP),1 (DEBUG_NEXT_TRIGGER)"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_DTEST"
      sgroup "PBS_CORE_SEQ_DEBUG_DTEST (at 0x70e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBUG_DTEST_SEL                          = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
    tree.end
    tree "PON_FSM_STATUS"
      sgroup "PON_FSM_STATUS (at 0x808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FSM_STATE                                = " "0 (OFF),1 (PON),2 (POFF),3 (ON),4 (DVDD_CONFIG),5 (RESERVED),6 (FAULT),7 (WARM_RESET)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (NOP_WD),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PU_DISABLED),1 (PU_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PU_DISABLED),1 (PU_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PU_DISABLED),1 (PU_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DEBOUNCE                                 = "
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_SMPL_CTL"
      sgroup "PON_SMPL_CTL (at 0x87f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80087f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x87f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SMPL_EN                                  = " "0 (SMPL_DISABLE),1 (SMPL_ENABLED)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PON_TRIGGER_EDGE_CONFIG"
      sgroup "PON_PON_TRIGGER_EDGE_CONFIG (at 0x881)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CBLPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB_CHG_REDGE_PON                        = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DC_CHG_REDGE_PON                         = " "0 (LEVEL),1 (REDGE)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CBLPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB_CHG_REDGE_PON                        = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DC_CHG_REDGE_PON                         = " "0 (LEVEL),1 (REDGE)"
    tree.end
    tree "PON_UVLO_CTL"
      sgroup "PON_UVLO_CTL (at 0x884)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_EN                                  = " "0 (UVLO_DISABLED),1 (UVLO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   UVLO_HYST                                = " "0 (MV_150),1 (MV_300),2 (MV_450),3 (MV_600)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   UVLO_THRESH                              = "
    tree.end
    tree "PON_UVLO_RB_STATUS"
      sgroup "PON_UVLO_RB_STATUS (at 0x885)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_RB                                  = " "0 (DEASSERTED),1 (ASSERTED)"
    tree.end
    tree "PON_OVLO_CTL"
      sgroup "PON_OVLO_CTL (at 0x886)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVLO_EN                                  = " "0 (OVLO_DISABLED),1 (OVLO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   OVLO_HYST                                = " "0 (MV_250),1 (MV_500),2 (MV_1000),3 (MV_2000)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   OVLO_THRESH                              = "
    tree.end
    tree "PON_OVLO_RB_STATUS"
      sgroup "PON_OVLO_RB_STATUS (at 0x887)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVLO_RB                                  = " "0 (DEASSERTED),1 (ASSERTED)"
    tree.end
    tree "PON_XVLO"
      sgroup "PON_XVLO (at 0x888)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   XVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_PBS_WDOG_PET"
      sgroup "PON_PBS_WDOG_PET (at 0x892)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PBS_WATCHDOG_PET                         = " "0 (NOP),1 (PET)"
    tree.end
    tree "PON_DEBUG_CTL"
      sgroup "PON_DEBUG_CTL (at 0x894)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEBUG_CLOCK                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEBUG_CLOCK_SRC                          = " "0 (RESIN_N),1 (CLK_32K_AON)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_DEBUG                                = "
    tree.end
    tree "PON_DEBUG_STATUS"
      sgroup "PON_DEBUG_STATUS (at 0x895)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEBUG_STATE                              = "
    tree.end
    tree "PON_RESET_CTL"
      sgroup "PON_RESET_CTL (at 0x898)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WARM_RB                                  = " "0 (ASSERTED),1 (DEASSERTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SHUTDOWN1_RB                             = " "0 (ASSERTED),1 (DEASSERTED)"
    tree.end
    tree "PON_PON_RESET_N_CTL"
      sgroup "PON_PON_RESET_N_CTL (at 0x899)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_RESET_N                              = " "0 (ASSERTED),1 (DEASSERTED)"
    tree.end
    tree "PON_PS_HOLD_STATUS"
      sgroup "PON_PS_HOLD_STATUS (at 0x89a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80089a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x89a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_HOLD                                  = " "0 (ASSERTED),1 (DEASSERTED)"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x8c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x8c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_ON_REASON"
      sgroup "PON_ON_REASON (at 0x8c4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_SEQ                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WARM_SEQ                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x8c5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_OFF_REASON"
      sgroup "PON_OFF_REASON (at 0x8c7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   POFF_SEQ                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FAULT_SEQ                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   S3_RESET                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IMMEDIATE_XVDD_SHUTDOWN                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAW_DVDD_RB_OCCURED                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAW_XVDD_RB_OCCURED                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_FAULT_REASON1"
      sgroup "PON_FAULT_REASON1 (at 0x8c8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBG_FAULT                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP_FAULT3                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GP_FAULT2                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GP_FAULT1                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GP_FAULT0                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_FAULT_REASON2"
      sgroup "PON_FAULT_REASON2 (at 0x8c9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESTART_PON                              = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PBS_NACK                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PBS_WATCHDOG_TO                          = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_S3_RESET_REASON"
      sgroup "PON_S3_RESET_REASON (at 0x8ca)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008ca0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8ca0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_ANDOR_RESIN                       = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PBS_NACK                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PBS_WATCHDOG_TO                          = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAULT_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x8cb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008cb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8cb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (SOFT_RESET_OCCURED_TEST_FALSE),1 (SOFT_RESET_OCCURED_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (PMIC_WD_BARK_TEST_FALSE),1 (PMIC_WD_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (K_R_BARK_TEST_FALSE),1 (K_R_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (RESIN_BARK_TEST_FALSE),1 (RESIN_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (KPDPWR_BARK_TEST_FALSE),1 (KPDPWR_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (CBLPWR_ON_TEST_FALSE),1 (CBLPWR_ON_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (RESIN_ON_TEST_FALSE),1 (RESIN_ON_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (KPDPWR_ON_TEST_FALSE),1 (KPDPWR_ON_TEST_TRUE)"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0 (UVLO_TEST_DISABLED),1 (UVLO_TEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVLO_TEST_EN                             = " "0 (OVLO_TEST_DISABLED),1 (OVLO_TEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0 (FORCE_ON_DISABLED),1 (FORCE_ON_ENABLED)"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_DEC_SEL                            = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3_SEL                               = "
    tree.end
    tree "PON_TEST4"
      sgroup "PON_TEST4 (at 0x8e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1_SEL                               = "
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0 (FOLLOW_DVDD_RB),1 (MASK_DVDD_RB)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0 (FOLLOW_SHUTDOWN1_RB),1 (MASK_SHUTDOWN1_RB)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0 (FOLLOW_SHUTDOWN2_RB),1 (MASK_SHUTDOWN2_RB)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0 (FOLLOW_WARM_RB),1 (MASK_WARM_RB)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0 (FOLLOW_GLOBAL_SOFT_RB),1 (MASK_GLOBAL_SOFT_RB)"
    tree.end
    tree "PON_TEST6"
      sgroup "PON_TEST6 (at 0x8e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IGNORE_CHG_PORB                          = " "0 (FOLLOW_CHG_PORB),1 (IGNORE_CHG_PORB)"
    tree.end
    tree "PON_TEST7"
      sgroup "PON_TEST7 (at 0x8e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FAULT_N_LOOPBACK                         = " "0 (FOLLOW_FAULT_N_BUS),1 (FOLLOW_FAULT_N_LOOPBACK)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DISCONNECT_FAULT_N                       = " "0 (CONNECT_FAULT_N),1 (DISCONNECT_FAULT_N)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IGNORE_FAULT_N                           = " "0 (FOLLOW_FAULT_N),1 (IGNORE_FAULT_N)"
    tree.end
    tree "PON_REG_WRITE_STATUS"
      sgroup "PON_REG_WRITE_STATUS (at 0x8ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WR_RDY                                   = " "0 (WR_WIP),1 (WR_RDY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WR_ILG                                   = " "0 (WR_OK),1 (WR_ILG)"
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
  tree.end
tree.end
tree "PON_OPTIONS"
  tree "PON_OPTIONS"
    tree "PON_OPTIONS_SPMI_SLAVE_RB"
      sgroup "PON_OPTIONS_SPMI_SLAVE_RB (at 0x20843)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_SLAVE_RB                            = " "0 (SPMI_SLAVE_RESET),1 (SPMI_SLAVE_ACTIVE)"
    tree.end
  tree.end
tree.end
tree "QNOVO"
  tree "QNOVO"
    tree "QNOVO_REVISION1"
      sgroup "QNOVO_REVISION1 (at 0x1500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "QNOVO_REVISION2"
      sgroup "QNOVO_REVISION2 (at 0x1501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "QNOVO_PERPH_TYPE"
      sgroup "QNOVO_PERPH_TYPE (at 0x1504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "QNOVO_PERPH_SUBTYPE"
      sgroup "QNOVO_PERPH_SUBTYPE (at 0x1505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "QNOVO_PTTIME_STS"
      sgroup "QNOVO_PTTIME_STS (at 0x1507)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PTTIME                                   = "
    tree.end
    tree "QNOVO_PTRAIN_STS"
      sgroup "QNOVO_PTRAIN_STS (at 0x1508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE1_DONE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PHASE2_DONE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PHASE3_DONE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIODE1                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIODE2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIODE3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VLIM                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INACT_TIME_EXP                           = " "0, 1"
    tree.end
    tree "QNOVO_ERROR_STATUS"
      sgroup "QNOVO_ERROR_STATUS (at 0x1509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_ERR                                 = " "0 (NO_ERROR),1 (ERROR_EXISTS)"
    tree.end
    tree "QNOVO_ERROR_STATUS2"
      sgroup "QNOVO_ERROR_STATUS2 (at 0x150a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80150a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x150a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RAW_CHGR_ERR                             = "
    tree.end
    tree "QNOVO_INT_RT_STS"
      sgroup "QNOVO_INT_RT_STS (at 0x1510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_SET_TYPE"
      sgroup "QNOVO_INT_SET_TYPE (at 0x1511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_POLARITY_HIGH"
      sgroup "QNOVO_INT_POLARITY_HIGH (at 0x1512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_POLARITY_LOW"
      sgroup "QNOVO_INT_POLARITY_LOW (at 0x1513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_LATCHED_CLR"
      sgroup "QNOVO_INT_LATCHED_CLR (at 0x1514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_EN_SET"
      sgroup "QNOVO_INT_EN_SET (at 0x1515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_EN_CLR"
      sgroup "QNOVO_INT_EN_CLR (at 0x1516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_LATCHED_STS"
      sgroup "QNOVO_INT_LATCHED_STS (at 0x1518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_PENDING_STS"
      sgroup "QNOVO_INT_PENDING_STS (at 0x1519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE                              = " "0, 1"
    tree.end
    tree "QNOVO_INT_MID_SEL"
      sgroup "QNOVO_INT_MID_SEL (at 0x151a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80151a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x151a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "QNOVO_INT_PRIORITY"
      sgroup "QNOVO_INT_PRIORITY (at 0x151b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80151b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x151b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "QNOVO_PE_CTRL"
      sgroup "QNOVO_PE_CTRL (at 0x1540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DISCHG_THRESH                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DISCHG_SAMPLES                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SW_INACT_TIMER                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PHASE3_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PHASE2_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHASE1_EN                                = " "0, 1"
    tree.end
    tree "QNOVO_PREST1_CTRL"
      sgroup "QNOVO_PREST1_CTRL (at 0x1541)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PREST1                                   = "
    tree.end
    tree "QNOVO_PPULS1_LSB_CTRL"
      sgroup "QNOVO_PPULS1_LSB_CTRL (at 0x1542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PPULS1_LSB                               = "
    tree.end
    tree "QNOVO_PPULS1_MSB_CTRL"
      sgroup "QNOVO_PPULS1_MSB_CTRL (at 0x1543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PPULS1_MSB                               = "
    tree.end
    tree "QNOVO_NREST1_CTRL"
      sgroup "QNOVO_NREST1_CTRL (at 0x1544)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NREST1                                   = "
    tree.end
    tree "QNOVO_NPULS1_CTRL"
      sgroup "QNOVO_NPULS1_CTRL (at 0x1545)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NPULS1                                   = "
    tree.end
    tree "QNOVO_PPCNT_CTRL"
      sgroup "QNOVO_PPCNT_CTRL (at 0x1546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PPCNT                                    = "
    tree.end
    tree "QNOVO_VLIM1_LSB_CTRL"
      sgroup "QNOVO_VLIM1_LSB_CTRL (at 0x1547)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VLIM1_LSB                                = "
    tree.end
    tree "QNOVO_VLIM1_MSB_CTRL"
      sgroup "QNOVO_VLIM1_MSB_CTRL (at 0x1548)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VLIM1_MSB                                = "
    tree.end
    tree "QNOVO_PTRAIN_EN"
      sgroup "QNOVO_PTRAIN_EN (at 0x1549)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_EN_CMD                            = " "0, 1"
    tree.end
    tree "QNOVO_PE_CTRL2"
      sgroup "QNOVO_PE_CTRL2 (at 0x154a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ZERO_CHARGE_DURING_GAP                   = " "0, 1"
    tree.end
    tree "QNOVO_PREST2_LSB_CTRL"
      sgroup "QNOVO_PREST2_LSB_CTRL (at 0x1550)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PREST2_LSB                               = "
    tree.end
    tree "QNOVO_PREST2_MSB_CTRL"
      sgroup "QNOVO_PREST2_MSB_CTRL (at 0x1551)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PREST2_MSB                               = "
    tree.end
    tree "QNOVO_PPULS2_LSB_CTRL"
      sgroup "QNOVO_PPULS2_LSB_CTRL (at 0x1552)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PPULS2_LSB                               = "
    tree.end
    tree "QNOVO_PPULS2_MSB_CTRL"
      sgroup "QNOVO_PPULS2_MSB_CTRL (at 0x1553)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PPULS2_MSB                               = "
    tree.end
    tree "QNOVO_NREST2_CTRL"
      sgroup "QNOVO_NREST2_CTRL (at 0x1554)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NREST2                                   = "
    tree.end
    tree "QNOVO_NPULS2_CTRL"
      sgroup "QNOVO_NPULS2_CTRL (at 0x1555)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NPULS2                                   = "
    tree.end
    tree "QNOVO_VLIM2_LSB_CTRL"
      sgroup "QNOVO_VLIM2_LSB_CTRL (at 0x1556)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VLIM2_LSB                                = "
    tree.end
    tree "QNOVO_VLIM2_MSB_CTRL"
      sgroup "QNOVO_VLIM2_MSB_CTRL (at 0x1557)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VLIM2_MSB                                = "
    tree.end
    tree "QNOVO_PVOLT1_LSB"
      sgroup "QNOVO_PVOLT1_LSB (at 0x1560)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PVOLT1_LSB                               = "
    tree.end
    tree "QNOVO_PVOLT1_MSB"
      sgroup "QNOVO_PVOLT1_MSB (at 0x1561)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PVOLT1_MSB                               = "
    tree.end
    tree "QNOVO_PCUR1_LSB"
      sgroup "QNOVO_PCUR1_LSB (at 0x1562)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PCUR1_LSB                                = "
    tree.end
    tree "QNOVO_PCUR1_MSB"
      sgroup "QNOVO_PCUR1_MSB (at 0x1563)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PCUR1_MSB                                = "
    tree.end
    tree "QNOVO_PVOLT2_LSB"
      sgroup "QNOVO_PVOLT2_LSB (at 0x1570)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PVOLT2_LSB                               = "
    tree.end
    tree "QNOVO_PVOLT2_MSB"
      sgroup "QNOVO_PVOLT2_MSB (at 0x1571)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PVOLT2_MSB                               = "
    tree.end
    tree "QNOVO_RVOLT2_LSB"
      sgroup "QNOVO_RVOLT2_LSB (at 0x1572)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RVOLT2_LSB                               = "
    tree.end
    tree "QNOVO_RVOLT2_MSB"
      sgroup "QNOVO_RVOLT2_MSB (at 0x1573)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RVOLT2_MSB                               = "
    tree.end
    tree "QNOVO_PCUR2_LSB"
      sgroup "QNOVO_PCUR2_LSB (at 0x1574)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PCUR2_LSB                                = "
    tree.end
    tree "QNOVO_PCUR2_MSB"
      sgroup "QNOVO_PCUR2_MSB (at 0x1575)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PCUR2_MSB                                = "
    tree.end
    tree "QNOVO_SCNT"
      sgroup "QNOVO_SCNT (at 0x1580)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SCNT                                     = "
    tree.end
    tree "QNOVO_VMAX_LSB"
      sgroup "QNOVO_VMAX_LSB (at 0x1590)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_LSB                                 = "
    tree.end
    tree "QNOVO_VMAX_MSB"
      sgroup "QNOVO_VMAX_MSB (at 0x1591)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VMAX_MSB                                 = "
    tree.end
    tree "QNOVO_SNUM"
      sgroup "QNOVO_SNUM (at 0x1592)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SNUM                                     = "
    tree.end
    tree "QNOVO_IADC_OFFSET_0"
      sgroup "QNOVO_IADC_OFFSET_0 (at 0x15a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_OFFSET_0                            = "
    tree.end
    tree "QNOVO_IADC_OFFSET_1"
      sgroup "QNOVO_IADC_OFFSET_1 (at 0x15a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_OFFSET_1                            = "
    tree.end
    tree "QNOVO_IADC_GAIN_0"
      sgroup "QNOVO_IADC_GAIN_0 (at 0x15a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_GAIN_0                              = "
    tree.end
    tree "QNOVO_IADC_GAIN_1"
      sgroup "QNOVO_IADC_GAIN_1 (at 0x15a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_GAIN_1                              = "
    tree.end
    tree "QNOVO_VADC_OFFSET"
      sgroup "QNOVO_VADC_OFFSET (at 0x15a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VADC_OFFSET                              = "
    tree.end
    tree "QNOVO_VADC_GAIN_0"
      sgroup "QNOVO_VADC_GAIN_0 (at 0x15a5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VADC_GAIN_0                              = "
    tree.end
    tree "QNOVO_VADC_GAIN_1"
      sgroup "QNOVO_VADC_GAIN_1 (at 0x15a6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VADC_GAIN_1                              = "
    tree.end
    tree "QNOVO_SPARE"
      sgroup "QNOVO_SPARE (at 0x15a7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "QNOVO_STRM_CTRL"
      sgroup "QNOVO_STRM_CTRL (at 0x15a8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INV_IADC_BITSTRM                         = " "0 (DONT_INVERT),1 (INVERT)"
    tree.end
    tree "QNOVO_IADC_OFFSET_OVR_VAL"
      sgroup "QNOVO_IADC_OFFSET_OVR_VAL (at 0x15a9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_OFFSET_OVR_VAL                      = "
    tree.end
    tree "QNOVO_IADC_OFFSET_OVR"
      sgroup "QNOVO_IADC_OFFSET_OVR (at 0x15aa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IADC_OFFSET_OVR                          = " "0, 1"
    tree.end
    tree "QNOVO_DISABLE_CHARGING"
      sgroup "QNOVO_DISABLE_CHARGING (at 0x15ab)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALLOW_ERROR                              = "
    tree.end
    tree "QNOVO_SEC_ACCESS"
      sgroup "QNOVO_SEC_ACCESS (at 0x15d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "QNOVO_PERPH_RESET_CTL2"
      sgroup "QNOVO_PERPH_RESET_CTL2 (at 0x15d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "QNOVO_PERPH_RESET_CTL3"
      sgroup "QNOVO_PERPH_RESET_CTL3 (at 0x15da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "QNOVO_PERPH_RESET_CTL4"
      sgroup "QNOVO_PERPH_RESET_CTL4 (at 0x15db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "QNOVO_INT_TEST1"
      sgroup "QNOVO_INT_TEST1 (at 0x15e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "QNOVO_INT_TEST_VAL"
      sgroup "QNOVO_INT_TEST_VAL (at 0x15e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_ERR_VAL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PTRAIN_DONE_VAL                          = " "0, 1"
    tree.end
    tree "QNOVO_TESTMODE_CTRL"
      sgroup "QNOVO_TESTMODE_CTRL (at 0x15e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_CTRL                                = "
    tree.end
    tree "QNOVO_TRIM_NUM"
      sgroup "QNOVO_TRIM_NUM (at 0x15f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "QNOVO_TR_IADC_OFFSET_0"
      sgroup "QNOVO_TR_IADC_OFFSET_0 (at 0x15f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IADC_OFFSET_0                         = "
    tree.end
    tree "QNOVO_TR_IADC_OFFSET_1"
      sgroup "QNOVO_TR_IADC_OFFSET_1 (at 0x15f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IADC_OFFSET_1                         = "
    tree.end
    tree "QNOVO_TR_IADC_GAIN_0"
      sgroup "QNOVO_TR_IADC_GAIN_0 (at 0x15f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IADC_GAIN_0                           = "
    tree.end
    tree "QNOVO_TR_IADC_GAIN_1"
      sgroup "QNOVO_TR_IADC_GAIN_1 (at 0x15f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IADC_GAIN_1                           = "
    tree.end
    tree "QNOVO_TR_VADC_OFFSET"
      sgroup "QNOVO_TR_VADC_OFFSET (at 0x15f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_VADC_OFFSET                           = "
    tree.end
    tree "QNOVO_TR_VADC_GAIN_0"
      sgroup "QNOVO_TR_VADC_GAIN_0 (at 0x15f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_VADC_GAIN_0                           = "
    tree.end
    tree "QNOVO_TR_VADC_GAIN_1"
      sgroup "QNOVO_TR_VADC_GAIN_1 (at 0x15f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_VADC_GAIN_1                           = "
    tree.end
    tree "QNOVO_TR_SPARE"
      sgroup "QNOVO_TR_SPARE (at 0x15f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_SPARE                                 = "
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_SBL_ID_0"
      sgroup "REVID_SBL_ID_0 (at 0x150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_SBL_ID_1"
      sgroup "REVID_SBL_ID_1 (at 0x151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_REV_ID_SPARE_0"
      sgroup "REVID_REV_ID_SPARE_0 (at 0x160)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID_REV_ID_SPARE_1"
      sgroup "REVID_REV_ID_SPARE_1 (at 0x161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TRIM_NUM"
      sgroup "REVID_TRIM_NUM (at 0x1f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "REVID_TP_REV"
      sgroup "REVID_TP_REV (at 0x1f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TP_REV                                   = "
    tree.end
    tree "REVID_FAB_ID"
      sgroup "REVID_FAB_ID (at 0x1f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FAB_ID                                   = "
    tree.end
    tree "REVID_WAFER_ID"
      sgroup "REVID_WAFER_ID (at 0x1f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   WAFER_ID                                 = "
    tree.end
    tree "REVID_X_COORD"
      sgroup "REVID_X_COORD (at 0x1f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   X_COORD                                  = "
    tree.end
    tree "REVID_Y_COORD"
      sgroup "REVID_Y_COORD (at 0x1f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   Y_COORD                                  = "
    tree.end
    tree "REVID_LOT_ID_11_10"
      sgroup "REVID_LOT_ID_11_10 (at 0x1f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_11_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_10_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_10_09"
      sgroup "REVID_LOT_ID_10_09 (at 0x1f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_10_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_09_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_09_08"
      sgroup "REVID_LOT_ID_09_08 (at 0x1f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_09_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_08_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_07_06"
      sgroup "REVID_LOT_ID_07_06 (at 0x1f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_07_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_06_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_06_05"
      sgroup "REVID_LOT_ID_06_05 (at 0x1fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_06_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_05_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_05_04"
      sgroup "REVID_LOT_ID_05_04 (at 0x1fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_05_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_04_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_03_02"
      sgroup "REVID_LOT_ID_03_02 (at 0x1fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_03_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_02_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_02_01"
      sgroup "REVID_LOT_ID_02_01 (at 0x1fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_02_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_01_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_01_00"
      sgroup "REVID_LOT_ID_01_00 (at 0x1fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_01_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_00_5_0                            = "
    tree.end
    tree "REVID_MFG_ID_SPARE"
      sgroup "REVID_MFG_ID_SPARE (at 0x1ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
  tree.end
tree.end
tree "SCHG8998_BATIF"
  tree "SCHG8998_BATIF"
    tree "SCHG8998_BATIF_PERPH_TYPE"
      sgroup "SCHG8998_BATIF_PERPH_TYPE (at 0x1204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SCHG8998_BATIF_PERPH_SUBTYPE"
      sgroup "SCHG8998_BATIF_PERPH_SUBTYPE (at 0x1205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SCHG8998_BATIF_SEC_ACCESS"
      sgroup "SCHG8998_BATIF_SEC_ACCESS (at 0x12d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SCHG8998_BATIF_PERPH_RESET_CTL2"
      sgroup "SCHG8998_BATIF_PERPH_RESET_CTL2 (at 0x12d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_PERPH_RESET_CTL3"
      sgroup "SCHG8998_BATIF_PERPH_RESET_CTL3 (at 0x12da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_PERPH_RESET_CTL4"
      sgroup "SCHG8998_BATIF_PERPH_RESET_CTL4 (at 0x12db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_SPARE"
      sgroup "SCHG8998_BATIF_SPARE (at 0x12df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_BATIF_INT_RT_STS"
      sgroup "SCHG8998_BATIF_INT_RT_STS (at 0x1210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_RT_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_RT_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_RT_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_RT_STS                          = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_SET_TYPE"
      sgroup "SCHG8998_BATIF_INT_SET_TYPE (at 0x1211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_TYPE                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_TYPE             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_TYPE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_TYPE                            = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_POLARITY_HIGH"
      sgroup "SCHG8998_BATIF_INT_POLARITY_HIGH (at 0x1212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_HIGH                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_HIGH             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_HIGH                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_HIGH                            = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_POLARITY_LOW"
      sgroup "SCHG8998_BATIF_INT_POLARITY_LOW (at 0x1213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_LOW                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_LOW              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_LOW                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_LOW                             = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_LATCHED_CLR"
      sgroup "SCHG8998_BATIF_INT_LATCHED_CLR (at 0x1214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_LATCHED_CLR      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_EN_SET"
      sgroup "SCHG8998_BATIF_INT_EN_SET (at 0x1215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_EN_SET              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_EN_SET           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_EN_SET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_EN_SET                          = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_EN_CLR"
      sgroup "SCHG8998_BATIF_INT_EN_CLR (at 0x1216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_EN_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_EN_CLR                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_EN_CLR                          = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_LATCHED_STS"
      sgroup "SCHG8998_BATIF_INT_LATCHED_STS (at 0x1218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_LATCHED_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_LATCHED_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_LATCHED_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_PENDING_STS"
      sgroup "SCHG8998_BATIF_INT_PENDING_STS (at 0x1219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_PENDING_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_PENDING_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_PENDING_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_MID_SEL"
      sgroup "SCHG8998_BATIF_INT_MID_SEL (at 0x121a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_BATIF_INT_PRIORITY"
      sgroup "SCHG8998_BATIF_INT_PRIORITY (at 0x121b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_TEST1"
      sgroup "SCHG8998_BATIF_INT_TEST1 (at 0x12e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_INT_TEST_VAL"
      sgroup "SCHG8998_BATIF_INT_TEST_VAL (at 0x12e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_7_VAL                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_6_VAL                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_VAL              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_VAL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_VAL                             = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_SHIP_MODE"
      sgroup "SCHG8998_BATIF_SHIP_MODE (at 0x1240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SHIP_MODE_EN                             = " "0, 1"
    tree.end
    tree "SCHG8998_BATIF_BATOCP_THRESHOLD_CFG"
      sgroup "SCHG8998_BATIF_BATOCP_THRESHOLD_CFG (at 0x1250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATOCP_ENABLE_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATOCP_THRESHOLD                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_BATIF_BATOCP_INTRPT_DELAY_TMR_CFG"
      sgroup "SCHG8998_BATIF_BATOCP_INTRPT_DELAY_TMR_CFG (at 0x1251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BATOCP_INTRPT_TIMEOUT                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATOCP_DELAY_TIMEOUT                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_BATIF_BATOCP_RESET_TMR_CFG"
      sgroup "SCHG8998_BATIF_BATOCP_RESET_TMR_CFG (at 0x1252)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_BATOCP_RESET_TMR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATOCP_RESET_TIMEOUT                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_BATIF_LOW_BATT_DETECT_EN_CFG"
      sgroup "SCHG8998_BATIF_LOW_BATT_DETECT_EN_CFG (at 0x1260)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENABLE_D_VBAT_LOW                        = " "0 (DIS_D_VBAT_LOW_ASSERTION),1 (EN_D_VBAT_LOW_ASSERTION)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOW_BATT_DETECT_EN                       = " "0 (LOW_BATTERY_DETECTION_IS_DISABLED),1 (LOW_BATTERY_DETECTION_IS_ENABLED)"
    tree.end
    tree "SCHG8998_BATIF_LOW_BATT_THRESHOLD_CFG"
      sgroup "SCHG8998_BATIF_LOW_BATT_THRESHOLD_CFG (at 0x1261)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOW_BATT_THRESHOLD                       = "
    tree.end
    tree "SCHG8998_BATIF_BAT_FET_CFG"
      sgroup "SCHG8998_BATIF_BAT_FET_CFG (at 0x1262)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BATFET_FULLON_5USEC_CHICKEN_BIT          = " "0 (BATFET_FULLON_WITH_NO_5USEC_DELAY),1 (BATFET_FULLON_AFTER_5USEC_DELAY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_FET_CFG                              = " "0 (BATTERY_FET_COMMAND_NOT_ALLOWED),1 (BATTERY_FET_COMMAND_ALLWED)"
    tree.end
    tree "SCHG8998_BATIF_BAT_MISS_SRC_CFG"
      sgroup "SCHG8998_BATIF_BAT_MISS_SRC_CFG (at 0x1270)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISS_ALG_EN                          = " "0 (BMA_DISABLED),1 (BMA_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_MISS_RESERVED                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_MISS_PIN_SRC_EN                      = " "0 (BATTERY_MISSING_NOT_USING_PIN),1 (BATTERY_MISSING_USING_PIN)"
    tree.end
    tree "SCHG8998_BATIF_BAT_MISS_ALG_OPTIONS_CFG"
      sgroup "SCHG8998_BATIF_BAT_MISS_ALG_OPTIONS_CFG (at 0x1271)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISS_INPUT_PLUGIN                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_MISS_TMR_START_OPTION                = " "0 (BMA_TMR_STARTS_AT_2V),1 (BMA_TMR_STARTS_IMMEDIATELY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_MISS_POLL_EN                         = " "0 (BMA_POLLER_DISABLED),1 (BMA_POLLER_ENABLED)"
    tree.end
    tree "SCHG8998_BATIF_BAT_MISS_PIN_GF_CFG"
      sgroup "SCHG8998_BATIF_BAT_MISS_PIN_GF_CFG (at 0x1272)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_MISS_PIN_GF                          = " "0 (BMD_RMV_80US),1 (BMD_RMV_160US),2 (BMD_RMV_320US),3 (BMD_RMV_640US)"
    tree.end
    tree "SCHG8998_BATIF_ENG_BATIF_CFG"
      sgroup "SCHG8998_BATIF_ENG_BATIF_CFG (at 0x12c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENG_SBQ_NGATE_PULLDWN                    = " "0 (ENG_SBQ_NGATE_PULLDWN_DIS),1 (ENG_SBQ_NGATE_PULLDWN_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_SBQ_VD_RLIM                          = " "0 (ENG_SBQ_VD_RLIM_DIS),1 (ENG_SBQ_VD_RLIM_EN)"
    tree.end
    tree "SCHG8998_BATIF_TRIM_NUM"
      sgroup "SCHG8998_BATIF_TRIM_NUM (at 0x12f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SCHG8998_BATIF_TR_SMISC_DPDM_PU"
      sgroup "SCHG8998_BATIF_TR_SMISC_DPDM_PU (at 0x12f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SMISC_DPDM_PU                         = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_BATIF_TR_SMISC_DPLUS_I"
      sgroup "SCHG8998_BATIF_TR_SMISC_DPLUS_I (at 0x12f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SMISC_DPLUS_I                         = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_BATIF_TR_SMISC_DPLUS_R"
      sgroup "SCHG8998_BATIF_TR_SMISC_DPLUS_R (at 0x12f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SMISC_DPLUS_R                         = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_BATIF_TR_SMISC_DFP_ISRC"
      sgroup "SCHG8998_BATIF_TR_SMISC_DFP_ISRC (at 0x12f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SMISC_DFP_ISRC                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_BATIF_TR_SMISC_RD_CC"
      sgroup "SCHG8998_BATIF_TR_SMISC_RD_CC (at 0x12f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SMISC_RD_CC                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_BATIF_TR_SMISC_FMB_2P5UA"
      sgroup "SCHG8998_BATIF_TR_SMISC_FMB_2P5UA (at 0x12f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SMISC_FMB_2P5UA                       = "
    tree.end
    tree "SCHG8998_BATIF_TR_SMISC_DPDM_50UA"
      sgroup "SCHG8998_BATIF_TR_SMISC_DPDM_50UA (at 0x12f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SMISC_DPDM_50UA                       = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "SCHG8998_CHGR"
  tree "SCHG8998_CHGR"
    tree "SCHG8998_CHGR_PERPH_TYPE"
      sgroup "SCHG8998_CHGR_PERPH_TYPE (at 0x1004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SCHG8998_CHGR_PERPH_SUBTYPE"
      sgroup "SCHG8998_CHGR_PERPH_SUBTYPE (at 0x1005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SCHG8998_CHGR_SEC_ACCESS"
      sgroup "SCHG8998_CHGR_SEC_ACCESS (at 0x10d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SCHG8998_CHGR_PERPH_RESET_CTL2"
      sgroup "SCHG8998_CHGR_PERPH_RESET_CTL2 (at 0x10d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_PERPH_RESET_CTL3"
      sgroup "SCHG8998_CHGR_PERPH_RESET_CTL3 (at 0x10da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_PERPH_RESET_CTL4"
      sgroup "SCHG8998_CHGR_PERPH_RESET_CTL4 (at 0x10db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_SPARE"
      sgroup "SCHG8998_CHGR_SPARE (at 0x10df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_1"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_1 (at 0x1006)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BVR_INITIAL_RAMP                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CC_SOFT_TERMINATE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   STEP_CHARGING_STATUS                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATTERY_CHARGER_STATUS                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_2"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_2 (at 0x1007)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_CURRENT_LIMITED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHARGER_ERROR_STATUS_SFT_EXPIRE          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CHARGER_ERROR_STATUS_BAT_OV              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHARGER_ERROR_STATUS_BAT_TERM_MISSING    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_TEMP_STATUS_HOT_SOFT_LIMIT           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_TEMP_STATUS_COLD_SOFT_LIMIT          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_STATUS_TOO_HOT                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_STATUS_TOO_COLD                 = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_3"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_3 (at 0x1009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FV_POST_JEITA                            = "
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_4"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_4 (at 0x100a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHARGE_CURRENT_POST_JEITA                = "
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_5"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_5 (at 0x100b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VALID_INPUT_POWER_SOURCE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DISABLE_CHARGING                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_ZERO_CHARGE_CURRENT                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHARGING_ENABLE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TAPER                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENABLE_CHG_SENSORS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENABLE_TAPER_SENSOR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TAPER_REGION                             = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_6"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_6 (at 0x100c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GF_BATT_OV                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DROP_IN_BATTERY_VOLTAGE_REFERENCE        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VBATT_LTET_RECHARGE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBATT_GTET_INHIBIT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBATT_GTET_FLOAT_VOLTAGE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_GT_PRE_TO_FAST                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BATT_GT_FULL_ON                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBATT_LT_2V                              = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_7"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_7 (at 0x100d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_TRICKLE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENABLE_PRE_CHARGING                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENABLE_FAST_CHARGING                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENABLE_FULLON_MODE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TOO_COLD_ADC                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TOO_HOT_ADC                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_SL_ADC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COLD_SL_ADC                              = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_8"
      sgroup "SCHG8998_CHGR_BATTERY_CHARGER_STATUS_8 (at 0x100e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PRE_FAST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PRE_FULLON                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PRE_RCHG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PRE_INHIBIT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PRE_OVRV                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PRE_TERM                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_ID_BMISS_CMP                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERM_CMP                                = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_RT_STS"
      sgroup "SCHG8998_CHGR_INT_RT_STS (at 0x1010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_RT_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_RT_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_RT_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_RT_STS  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_RT_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_RT_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_RT_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_RT_STS                        = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_SET_TYPE"
      sgroup "SCHG8998_CHGR_INT_SET_TYPE (at 0x1011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_TYPE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_TYPE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_TYPE                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_TYPE    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_TYPE       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_TYPE          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_TYPE               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_TYPE                          = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_POLARITY_HIGH"
      sgroup "SCHG8998_CHGR_INT_POLARITY_HIGH (at 0x1012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_HIGH                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_HIGH                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_HIGH                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_HIGH    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_HIGH       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_HIGH          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_HIGH               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_HIGH                          = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_POLARITY_LOW"
      sgroup "SCHG8998_CHGR_INT_POLARITY_LOW (at 0x1013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_LOW                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_LOW                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_LOW                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_LOW     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_LOW        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_LOW           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_LOW                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LOW                           = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_LATCHED_CLR"
      sgroup "SCHG8998_CHGR_INT_LATCHED_CLR (at 0x1014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_LATCHED_CLR = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_LATCHED_CLR = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_LATCHED_CLR   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_EN_SET"
      sgroup "SCHG8998_CHGR_INT_EN_SET (at 0x1015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_EN_SET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_EN_SET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_EN_SET                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_EN_SET  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_EN_SET     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_EN_SET        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_EN_SET             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_SET                        = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_EN_CLR"
      sgroup "SCHG8998_CHGR_INT_EN_CLR (at 0x1016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_EN_CLR                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_EN_CLR                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_EN_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_EN_CLR  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_EN_CLR     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_EN_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_EN_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_CLR                        = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_LATCHED_STS"
      sgroup "SCHG8998_CHGR_INT_LATCHED_STS (at 0x1018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_LATCHED_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_LATCHED_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_LATCHED_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_LATCHED_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_LATCHED_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_LATCHED_STS   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_LATCHED_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_PENDING_STS"
      sgroup "SCHG8998_CHGR_INT_PENDING_STS (at 0x1019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_PENDING_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_PENDING_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_PENDING_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_PENDING_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_PENDING_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_PENDING_STS   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_PENDING_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_PENDING_STS                   = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_MID_SEL"
      sgroup "SCHG8998_CHGR_INT_MID_SEL (at 0x101a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_CHGR_INT_PRIORITY"
      sgroup "SCHG8998_CHGR_INT_PRIORITY (at 0x101b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_TEST1"
      sgroup "SCHG8998_CHGR_INT_TEST1 (at 0x10e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_INT_TEST_VAL"
      sgroup "SCHG8998_CHGR_INT_TEST_VAL (at 0x10e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHGR_7_VAL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_6_VAL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FG_FVCAL_QUALIFIED_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_VAL     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_VAL        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_VAL           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_VAL                           = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_CHG_OPTION"
      sgroup "SCHG8998_CHGR_CHG_OPTION (at 0x1008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN                                      = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_VBATT_V"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_VBATT_V (at 0x1040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STEP_CHG_SOC_VBATT_V                     = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_VBATT_V_UPDATE"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_VBATT_V_UPDATE (at 0x1041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEP_CHG_SOC_VBATT_V_UPDATE              = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_CHARGING_ENABLE_CMD"
      sgroup "SCHG8998_CHGR_CHARGING_ENABLE_CMD (at 0x1042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGING_ENABLE_CMD                      = " "0 (CHARGING_ENABLE_CMD_IS_INACTIVE),1 (CHARGING_ENABLE_CMD_IS_ACTIVE)"
    tree.end
    tree "SCHG8998_CHGR_ALLOW_FAST_CHARGING_CMD"
      sgroup "SCHG8998_CHGR_ALLOW_FAST_CHARGING_CMD (at 0x1043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALLOW_FAST_CHARGING_CMD                  = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_QNOVO_PT_ENABLE_CMD"
      sgroup "SCHG8998_CHGR_QNOVO_PT_ENABLE_CMD (at 0x1044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   QNOVO_PT_ENABLE_CMD                      = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_CHGR_CFG1"
      sgroup "SCHG8998_CHGR_CHGR_CFG1 (at 0x1050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CHGR_CHICKEN_BIT                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CC_ERROR_BMA_EN_INT                      = " "0 (CC_ERROR_BMA_DIS_INT),1 (CC_ERROR_BMA_EN_INT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CC_ERROR_SAFETY_TIMER_EN_INT             = " "0 (CC_ERROR_SAFETY_TIMER_DIS_INT),1 (CC_ERROR_SAFETY_TIMER_EN_INT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CC_ERROR_BATOV_EN_INT                    = " "0 (CC_ERROR_BATOV_DIS_INT),1 (CC_ERROR_BATOV_EN_INT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TAPER_LOW_DEGLITCH_TIMEOUT               = " "0 (TAPER_LOW_DEGLITCH_TIMEOUT_80MS),1 (TAPER_LOW_DEGLITCH_TIMEOUT_300MS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INCREASE_RCHG_TIMEOUT_CFG                = " "0 (RECHARGE_GF_20MS),1 (RECHARGE_GF_5S)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOAD_BAT                                 = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_CHGR_CFG2"
      sgroup "SCHG8998_CHGR_CHGR_CFG2 (at 0x1051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_EN_SRC                               = " "0 (CHG_EN_SRC_CMD),1 (CHG_EN_SRC_PIN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_EN_POLARITY                          = " "0 (CHG_EN_POL_HIGH),1 (CHG_EN_POL_LOW)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PRETOFAST_TRANSITION_CFG                 = " "0 (PRE_FAST_AUTO),1 (PRE_FAST_CMD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_ECC                               = " "0 (BATT_OV_ENDS_CYCLE_DIS),1 (BATT_OV_ENDS_CYCLE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   I_TERM                                   = " "0 (CURRENT_TERM_EN),1 (CURRENT_TERM_DIS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTO_RECHG                               = " "0 (AUTO_RCHG_EN),1 (AUTO_RCHG_DIS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_ANALOG_DROP_IN_VBATT                  = " "0 (ANALOG_DROP_IN_VBATT_DIS),1 (ANALOG_DROP_IN_VBATT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGER_INHIBIT                          = " "0 (CHG_INHIBIT_DIS),1 (CHG_INHIBIT_EN)"
    tree.end
    tree "SCHG8998_CHGR_CHARGER_ENABLE_CFG"
      sgroup "SCHG8998_CHGR_CHARGER_ENABLE_CFG (at 0x1052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   TERM_QUALIFY                             = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHG_ENB_TIMEOUT_SETTING                  = " "0 (CHG_ENB_TMR_30MS),1 (CHG_ENB_TMR_300MS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_ZERO_CFG                           = " "0 (CHG_CUR_RAMPDWN_CFG1),1 (CHG_CUR_RAMPDWN_CFG2)"
    tree.end
    tree "SCHG8998_CHGR_CFG"
      sgroup "SCHG8998_CHGR_CFG (at 0x1053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_OPTION_PIN_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHGR_ADDITIONAL_300MS_HOLDOFF_TIMER_EN   = " "0 (CHGR_ADDITIONAL_300MS_HOLDOFF_TIMER_DIS),1 (CHGR_ADDITIONAL_300MS_HOLDOFF_TIMER_ENB)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BATFET_OPEN_FAULT_EN                     = " "0 (DONT_GEN_PON_FAULT),1 (GEN_PON_FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATN_SNS_CFG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CFG_TAPER_DIS_AFVC                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATFET_SHUTDOWN_CFG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VDISCHG_EN_CFG                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VCHG_EN_CFG                              = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_CC_STATE_INT_EN"
      sgroup "SCHG8998_CHGR_CC_STATE_INT_EN (at 0x1054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CC_STATE_TRICKLE_EN_INT                  = " "0 (CC_STATE_TRICKLE_DIS_INT),1 (CC_STATE_TRICKLE_EN_INT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CC_STATE_PRECHARGE_EN_INT                = " "0 (CC_STATE_PRECHARGE_DIS_INT),1 (CC_STATE_PRECHARGE_EN_INT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CC_STATE_FAST_EN_INT                     = " "0 (CC_STATE_FAST_DIS_INT),1 (CC_STATE_FAST_EN_INT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CC_STATE_FULLON_EN_INT                   = " "0 (CC_STATE_FULLON_DIS_INT),1 (CC_STATE_FULLON_EN_INT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CC_STATE_TAPER_EN_INT                    = " "0 (CC_STATE_TAPER_DIS_INT),1 (CC_STATE_TAPER_EN_INT)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CC_STATE_INVALID_EN_INT                  = " "0 (CC_STATE_INVALID_DIS_INT),1 (CC_STATE_INVALID_EN_INT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_STATE_TERMINATE_EN_INT                = " "0 (CC_STATE_TERMINATE_DIS_INT),1 (CC_STATE_TERMINATE_EN_INT)"
    tree.end
    tree "SCHG8998_CHGR_PRE_CHARGE_CURRENT_CFG"
      sgroup "SCHG8998_CHGR_PRE_CHARGE_CURRENT_CFG (at 0x1060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRE_CHARGE_CURRENT_SETTING               = "
    tree.end
    tree "SCHG8998_CHGR_FAST_CHARGE_CURRENT_CFG"
      sgroup "SCHG8998_CHGR_FAST_CHARGE_CURRENT_CFG (at 0x1061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FAST_CHARGE_CURRENT_SETTING              = "
    tree.end
    tree "SCHG8998_CHGR_CHARGE_CURRENT_TERMINATION_CFG"
      sgroup "SCHG8998_CHGR_CHARGE_CURRENT_TERMINATION_CFG (at 0x1062)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ANALOG_CHARGE_CURRENT_TERMINATION_SETTING = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_CHGR_TCCC_CHARGE_CURRENT_TERMINATION_CFG"
      sgroup "SCHG8998_CHGR_TCCC_CHARGE_CURRENT_TERMINATION_CFG (at 0x1063)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TCCC_CHARGE_CURRENT_TERMINATION_SETTING  = "
    tree.end
    tree "SCHG8998_CHGR_CHARGE_CURRENT_SOFTSTART_SETTING_CFG"
      sgroup "SCHG8998_CHGR_CHARGE_CURRENT_SOFTSTART_SETTING_CFG (at 0x1064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHARGE_CURRENT_SOFTSTART_SETTING         = " "0 (CHARGE_CURRENT_SOFTSTART_RATE_IS_25MA_PER_100US),1 (CHARGE_CURRENT_SOFTSTART_RATE_IS_25MA_PER_200US),2 (CHARGE_CURRENT_SOFTSTART_RATE_IS_25MA_PER_400US),3 (CHARGE_CURRENT_SOFTSTART_RATE_IS_25MA_PER_800US)"
    tree.end
    tree "SCHG8998_CHGR_FLOAT_VOLTAGE_CFG"
      sgroup "SCHG8998_CHGR_FLOAT_VOLTAGE_CFG (at 0x1070)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FLOAT_VOLTAGE_SETTING                    = "
    tree.end
    tree "SCHG8998_CHGR_AUTO_FLOAT_VOLTAGE_COMPENSATION_CFG"
      sgroup "SCHG8998_CHGR_AUTO_FLOAT_VOLTAGE_COMPENSATION_CFG (at 0x1071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   AUTO_FLOAT_VOLTAGE_COMPENSATION          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_CHGR_CHARGE_INHIBIT_THRESHOLD_CFG"
      sgroup "SCHG8998_CHGR_CHARGE_INHIBIT_THRESHOLD_CFG (at 0x1072)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHARGE_INHIBIT_THRESHOLD                 = " "0 (INHIBIT_ANALOG_VFLT_MINUS_50MV),1 (INHIBIT_ANALOG_VFLT_MINUS_100MV),2 (INHIBIT_ANALOG_VFLT_MINUS_200MV),3 (INHIBIT_ANALOG_VFLT_MINUS_300MV)"
    tree.end
    tree "SCHG8998_CHGR_RECHARGE_THRESHOLD_CFG"
      sgroup "SCHG8998_CHGR_RECHARGE_THRESHOLD_CFG (at 0x1073)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RECHARGE_THRESHOLD                       = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_CHGR_PRE_TO_FAST_CHARGE_THRESHOLD_CFG"
      sgroup "SCHG8998_CHGR_PRE_TO_FAST_CHARGE_THRESHOLD_CFG (at 0x1074)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRE_TO_FAST_CHARGE_THRESHOLD             = " "0 (P2F_ANALOG_2P4V),1 (P2F_ANALOG_2P6V),2 (P2F_ANALOG_2P8V),3 (P2F_ANALOG_3P0V)"
    tree.end
    tree "SCHG8998_CHGR_FV_HYSTERESIS_CFG"
      sgroup "SCHG8998_CHGR_FV_HYSTERESIS_CFG (at 0x1075)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   FV_DROP_HYSTERESIS_CFG                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   THRESH_HYSTERESIS_CFG                    = "
    tree.end
    tree "SCHG8998_CHGR_FVC_CHARGE_INHIBIT_THRESHOLD_CFG"
      sgroup "SCHG8998_CHGR_FVC_CHARGE_INHIBIT_THRESHOLD_CFG (at 0x1080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FVC_CHARGE_INHIBIT_THRESHOLD             = "
    tree.end
    tree "SCHG8998_CHGR_FVC_RECHARGE_THRESHOLD_CFG"
      sgroup "SCHG8998_CHGR_FVC_RECHARGE_THRESHOLD_CFG (at 0x1081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FVC_RECHARGE_THRESHOLD                   = "
    tree.end
    tree "SCHG8998_CHGR_FVC_PRE_TO_FAST_CHARGE_THRESHOLD_CFG"
      sgroup "SCHG8998_CHGR_FVC_PRE_TO_FAST_CHARGE_THRESHOLD_CFG (at 0x1082)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FVC_PRE_TO_FAST_CHARGE_THRESHOLD         = "
    tree.end
    tree "SCHG8998_CHGR_FVC_FULL_ON_THRESHOLD_CFG"
      sgroup "SCHG8998_CHGR_FVC_FULL_ON_THRESHOLD_CFG (at 0x1083)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FVC_FULL_ON_THRESHOLD                    = "
    tree.end
    tree "SCHG8998_CHGR_FVC_CC_MODE_GLITCH_FILTER_SEL_CFG"
      sgroup "SCHG8998_CHGR_FVC_CC_MODE_GLITCH_FILTER_SEL_CFG (at 0x1084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FVC_CC_MODE_GLITCH_FILTER_SEL            = " "0 (FVC_CC_MODE_GLITCH_FILTER_100MS),1 (FVC_CC_MODE_GLITCH_FILTER_50MS),2 (FVC_CC_MODE_GLITCH_FILTER_24MS),3 (FVC_CC_MODE_GLITCH_FILTER_16MS)"
    tree.end
    tree "SCHG8998_CHGR_FVC_TERMINATION_GLITCH_FILTER_SEL_CFG"
      sgroup "SCHG8998_CHGR_FVC_TERMINATION_GLITCH_FILTER_SEL_CFG (at 0x1085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FVC_TERMINATION_GLITCH_FILTER_SEL        = " "0 (FVC_TERMINATION_GLITCH_FILTER_100MS),1 (FVC_TERMINATION_GLITCH_FILTER_50MS),2 (FVC_TERMINATION_GLITCH_FILTER_25MS),3 (FVC_TERMINATION_GLITCH_FILTER_1MS)"
    tree.end
    tree "SCHG8998_CHGR_JEITA_EN_CFG"
      sgroup "SCHG8998_CHGR_JEITA_EN_CFG (at 0x1090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   JEITA_EN_FVCOMP_IN_CV                    = " "0 (JEITA_EN_FVCOMP_IN_CV_DIS),1 (JEITA_EN_FVCOMP_IN_CV_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   JEITA_EN_HARDLIMIT                       = " "0 (JEITA_TEMP_HARD_LIMIT_DIS),1 (JEITA_TEMP_HARD_LIMIT_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   JEITA_EN_HOT_SL_FCV                      = " "0 (JEITA_HOT_SOFT_LIMIT_FV_COMP_DIS),1 (JEITA_HOT_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   JEITA_EN_COLD_SL_FCV                     = " "0 (JEITA_COLD_SOFT_LIMIT_FV_COMP_DIS),1 (JEITA_COLD_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_EN_HOT_SL_CCC                      = " "0 (JEITA_HOT_SOFT_LIMIT_CC_COMP_DIS),1 (JEITA_HOT_SOFT_LIMIT_CC_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_EN_COLD_SL_CCC                     = " "0 (JEITA_COLD_SOFT_LIMIT_CC_COMP_DIS),1 (JEITA_COLD_SOFT_LIMIT_CC_COMP_EN)"
    tree.end
    tree "SCHG8998_CHGR_JEITA_FVCOMP_CFG"
      sgroup "SCHG8998_CHGR_JEITA_FVCOMP_CFG (at 0x1091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   JEITA_FVCOMP                             = "
    tree.end
    tree "SCHG8998_CHGR_JEITA_CCCOMP_CFG"
      sgroup "SCHG8998_CHGR_JEITA_CCCOMP_CFG (at 0x1092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   JEITA_CCCOMP                             = "
    tree.end
    tree "SCHG8998_CHGR_SAFETY_TIMER_ENABLE_CFG"
      sgroup "SCHG8998_CHGR_SAFETY_TIMER_ENABLE_CFG (at 0x10a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PRE_CHARGE_SAFETY_TIMER_EN               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FAST_CHARGE_SAFETY_TIMER_EN              = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_PRE_CHARGE_SAFETY_TIMER_CFG"
      sgroup "SCHG8998_CHGR_PRE_CHARGE_SAFETY_TIMER_CFG (at 0x10a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRECHARGE_SAFETY_TIMER                   = " "0 (PC_TMOUT_24MIN),1 (PC_TMOUT_48MIN),2 (PC_TMOUT_96MIN),3 (PC_TMOUT_192MIN)"
    tree.end
    tree "SCHG8998_CHGR_FAST_CHARGE_SAFETY_TIMER_CFG"
      sgroup "SCHG8998_CHGR_FAST_CHARGE_SAFETY_TIMER_CFG (at 0x10a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FAST_CHARGE_SAFETY_TIMER                 = " "0 (FC_TMOUT_192MIN),1 (FC_TMOUT_384MIN),2 (FC_TMOUT_768MIN),3 (FC_TMOUT_1536MIN)"
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_MODE_CFG"
      sgroup "SCHG8998_CHGR_STEP_CHG_MODE_CFG (at 0x10b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_FAIL_OPTION            = " "0 (STEP_CHARGING_STANDARD_MODE),1 (STEP_CHARGING_AUTONOMOUS_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_MODE_SELECT                = " "0 (STEP_CHARGING_STANDARD_MODE),1 (STEP_CHARGING_AUTONOMOUS_MODE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STEP_CHARGING_SOURCE_SELECT              = " "0 (STEP_CHARGING_CONTROL_FROM_SOC),1 (STEP_CHARGING_CONTROL_FROM_VBATT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEP_CHARGING_ENABLE                     = " "0 (STEP_CHARGING_DISABLED),1 (STEP_CHARGING_ENABLED)"
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_CFG"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_CFG (at 0x10b1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT = " "0 (STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_5S),1 (STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_10S),2 (STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_20S),3 (STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_40S)"
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_CFG"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_CFG (at 0x10b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT = " "0 (STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_10S),1 (STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_30S),2 (STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_60S),3 (STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_120S)"
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD1"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD1 (at 0x10b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD1        = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD2"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD2 (at 0x10b4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD2        = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD3"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD3 (at 0x10b5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD3        = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD4"
      sgroup "SCHG8998_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD4 (at 0x10b6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD4        = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA1"
      sgroup "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA1 (at 0x10b7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA1                  = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA2"
      sgroup "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA2 (at 0x10b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA2                  = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA3"
      sgroup "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA3 (at 0x10b9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA3                  = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA4"
      sgroup "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA4 (at 0x10ba)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA4                  = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA5"
      sgroup "SCHG8998_CHGR_STEP_CHG_CURRENT_DELTA5 (at 0x10bb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA5                  = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_FV_DELTA1"
      sgroup "SCHG8998_CHGR_STEP_CHG_FV_DELTA1 (at 0x10bc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA1                       = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_FV_DELTA2"
      sgroup "SCHG8998_CHGR_STEP_CHG_FV_DELTA2 (at 0x10bd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA2                       = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_FV_DELTA3"
      sgroup "SCHG8998_CHGR_STEP_CHG_FV_DELTA3 (at 0x10be)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010be0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10be0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA3                       = "
    tree.end
    tree "SCHG8998_CHGR_STEP_CHG_FV_DELTA4"
      sgroup "SCHG8998_CHGR_STEP_CHG_FV_DELTA4 (at 0x10bf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA4                       = "
    tree.end
    tree "SCHG8998_CHGR_FV_CAL_CFG"
      sgroup "SCHG8998_CHGR_FV_CAL_CFG (at 0x1076)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATFETOFF_DURING_QNOVO_DISCHARGE         = " "0 (BATFET_NOTOFF_DURING_QNOVO_DISCHARGE),1 (BATFET_OFF_DURING_QNOVO_DISCHARGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SUBTRACT_CC_DURING_ESR                   = " "0 (JUMP_CC_DURING_ESR),1 (SUBTRACT_CC_DURING_ESR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FV_CALIBRATION_CFG                       = " "0 (WAIT_FOR_1_FG_UPDATE_DECREMENTING_CHARGE_CURRENT_IN_TAPER),1 (WAIT_FOR_2_FG_UPDATES_DECREMENTING_CHARGE_CURRENT_IN_TAPER),2 (WAIT_FOR_3_FG_UPDATES_DECREMENTING_CHARGE_CURRENT_IN_TAPER),3 (WAIT_FOR_4_FG_UPDATES_DECREMENTING_CHARGE_CURRENT_IN_TAPER),4 (WAIT_FOR_5_FG_UPDATES_DECREMENTING_CHARGE_CURRENT_IN_TAPER),5 (WAIT_FOR_6_FG_UPDATES_DECREMENTING_CHARGE_CURRENT_IN_TAPER),6 (WAIT_FOR_7_FG_UPDATES_DECREMENTING_CHARGE_CURRENT_IN_TAPER),7 (WAIT_FOR_0_FG_UPDATES_DECREMENTING_CHARGE_CURRENT_IN_TAPER)"
    tree.end
    tree "SCHG8998_CHGR_FV_ADJUST"
      sgroup "SCHG8998_CHGR_FV_ADJUST (at 0x1077)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FLOAT_VOLTAGE_ADJUSTMENT                 = "
    tree.end
    tree "SCHG8998_CHGR_FG_VADC_DISQ_THRESH"
      sgroup "SCHG8998_CHGR_FG_VADC_DISQ_THRESH (at 0x1078)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VADC_DISQUAL_THRESH                      = "
    tree.end
    tree "SCHG8998_CHGR_FG_IADC_DISQ_THRESH"
      sgroup "SCHG8998_CHGR_FG_IADC_DISQ_THRESH (at 0x1079)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IADC_DISQUAL_THRESH                      = "
    tree.end
    tree "SCHG8998_CHGR_FG_UPDATE_CFG_1"
      sgroup "SCHG8998_CHGR_FG_UPDATE_CFG_1 (at 0x107a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80107a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x107a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BT_TMPR_TCOLD                            = " "0 (FG_BT_TMPR_TCOLD_LOW),1 (FG_BT_TMPR_TCOLD_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_COLD                             = " "0 (FG_BT_TMPR_COLD_LOW),1 (FG_BT_TMPR_COLD_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BT_TMPR_HOT                              = " "0 (FG_BT_TMPR_HOT_LOW),1 (FG_BT_TMPR_HOT_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_TMPR_THOT                             = " "0 (FG_BT_TMPR_THOT_LOW),1 (FG_BT_TMPR_THOT_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHG_DIE_TMPR_HOT                         = " "0 (FG_CHG_DIE_TMPR_HOT_LOW),1 (FG_CHG_DIE_TMPR_HOT_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_DIE_TMPR_THOT                        = " "0 (FG_CHG_DIE_TMPR_THOT_LOW),1 (FG_CHG_DIE_TMPR_THOT_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SKIN_TMPR_HOT                            = " "0 (FG_SKIN_TMPR_HOT_LOW),1 (FG_SKIN_TMPR_HOT_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SKIN_TMPR_THOT                           = " "0 (FG_SKIN_TMPR_THOT_LOW),1 (FG_SKIN_TMPR_THOT_HIGH)"
    tree.end
    tree "SCHG8998_CHGR_FG_UPDATE_CFG_1_SEL"
      sgroup "SCHG8998_CHGR_FG_UPDATE_CFG_1_SEL (at 0x107b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80107b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x107b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BT_TMPR_TCOLD_SEL                        = " "0 (FG_BT_TMPR_TCOLD_SEL_LOW),1 (FG_BT_TMPR_TCOLD_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_COLD_SEL                         = " "0 (FG_BT_TMPR_COLD_SEL_LOW),1 (FG_BT_TMPR_COLD_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BT_TMPR_HOT_SEL                          = " "0 (FG_BT_TMPR_HOT_SEL_LOW),1 (FG_BT_TMPR_HOT_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_TMPR_THOT_SEL                         = " "0 (FG_BT_TMPR_THOT_SEL_LOW),1 (FG_BT_TMPR_THOT_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHG_DIE_TMPR_HOT_SEL                     = " "0 (FG_CHG_DIE_TMPR_HOT_SEL_LOW),1 (FG_CHG_DIE_TMPR_HOT_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHG_DIE_TMPR_THOT_SEL                    = " "0 (FG_CHG_DIE_TMPR_THOT_SEL_LOW),1 (FG_CHG_DIE_TMPR_THOT_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SKIN_TMPR_HOT_SEL                        = " "0 (FG_SKIN_TMPR_HOT_SEL_LOW),1 (FG_SKIN_TMPR_HOT_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SKIN_TMPR_THOT_SEL                       = " "0 (FG_SKIN_TMPR_THOT_SEL_LOW),1 (FG_SKIN_TMPR_THOT_SEL_HIGH)"
    tree.end
    tree "SCHG8998_CHGR_FG_UPDATE_CFG_2"
      sgroup "SCHG8998_CHGR_FG_UPDATE_CFG_2 (at 0x107c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80107c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x107c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SOC_LT_OTG_THRESH                        = " "0 (FG_SOC_LT_OTG_THRESH_LOW),1 (FG_SOC_LT_OTG_THRESH_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SOC_LT_CHG_RECHARGE_THRESH               = " "0 (FG_SOC_LT_CHG_RECHARGE_THRESH_LOW),1 (FG_SOC_LT_CHG_RECHARGE_THRESH_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LT_CHG_RECHARGE_THRESH               = " "0 (FG_VBT_LT_CHG_RECHARGE_THRESH_LOW),1 (FG_VBT_LT_CHG_RECHARGE_THRESH_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_LT_CHG_TERM_THRESH                   = " "0 (FG_IBT_LT_CHG_TERM_THRESH_LOW),1 (FG_IBT_LT_CHG_TERM_THRESH_HIGH)"
    tree.end
    tree "SCHG8998_CHGR_FG_UPDATE_CFG_2_SEL"
      sgroup "SCHG8998_CHGR_FG_UPDATE_CFG_2_SEL (at 0x107d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80107d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x107d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SOC_LT_OTG_THRESH_SEL                    = " "0 (FG_SOC_LT_OTG_THRESH_SEL_LOW),1 (FG_SOC_LT_OTG_THRESH_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SOC_LT_CHG_RECHARGE_THRESH_SEL           = " "0 (FG_SOC_LT_CHG_RECHARGE_THRESH_SEL_LOW),1 (FG_SOC_LT_CHG_RECHARGE_THRESH_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LT_CHG_RECHARGE_THRESH_SEL           = " "0 (FG_VBT_LT_CHG_RECHARGE_THRESH_SEL_LOW),1 (FG_VBT_LT_CHG_RECHARGE_THRESH_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_LT_CHG_TERM_THRESH_SEL               = " "0 (FG_IBT_LT_CHG_TERM_THRESH_SEL_LOW),1 (FG_IBT_LT_CHG_TERM_THRESH_SEL_HIGH)"
    tree.end
    tree "SCHG8998_CHGR_FG_CHG_INTERFACE_CFG"
      sgroup "SCHG8998_CHGR_FG_CHG_INTERFACE_CFG (at 0x107e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80107e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x107e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ESR_ISINK_CFG                            = " "0 (FG_ESR_ISINK_CFG_LOW),1 (FG_ESR_ISINK_CFG_HIGH),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ESR_FASTCHG_DECR_CFG                     = " "0 (FG_ESR_FASTCHG_DECR_CFG_LOW),1 (FG_ESR_FASTCHG_DECR_CFG_HIGH),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_CHARGER_INHIBIT                       = " "0 (FG_CHARGER_INHIBIT_LOW),1 (FG_CHARGER_INHIBIT_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FG_BATFET                                = " "0 (FG_BATFET_LOW),1 (FG_BATFET_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IADC_SYNC_CNV                            = " "0 (FG_IADC_SYNC_CNV_LOW),1 (FG_IADC_SYNC_CNV_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VADC_SYNC_CNV                            = " "0 (FG_VADC_SYNC_CNV_LOW),1 (FG_VADC_SYNC_CNV_HIGH)"
    tree.end
    tree "SCHG8998_CHGR_FG_CHG_INTERFACE_CFG_SEL"
      sgroup "SCHG8998_CHGR_FG_CHG_INTERFACE_CFG_SEL (at 0x107f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80107f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x107f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ESR_ISINK_CFG_SEL                        = " "0 (FG_ESR_ISINK_CFG_SEL_LOW),1 (FG_ESR_ISINK_CFG_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ESR_FASTCHG_DECR_CFG_SEL                 = " "0 (FG_ESR_FASTCHG_DECR_CFG_SEL_LOW),1 (FG_ESR_FASTCHG_DECR_CFG_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_CHARGER_INHIBIT_SEL                   = " "0 (FG_CHARGER_INHIBIT_SEL_LOW),1 (FG_CHARGER_INHIBIT_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FG_BATFET_SEL                            = " "0 (FG_BATFET_SEL_LOW),1 (FG_BATFET_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IADC_SYNC_CNV_SEL                        = " "0 (FG_IADC_SYNC_CNV_SEL_LOW),1 (FG_IADC_SYNC_CNV_SEL_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VADC_SYNC_CNV_SEL                        = " "0 (FG_VADC_SYNC_CNV_SEL_LOW),1 (FG_VADC_SYNC_CNV_SEL_HIGH)"
    tree.end
    tree "SCHG8998_CHGR_ENG_CHARGING_CFG"
      sgroup "SCHG8998_CHGR_ENG_CHARGING_CFG (at 0x10c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USE_ANALOG_CHARGING_LEVELS               = " "0 (USE_DIGITAL_CHARGING_LEVELS),1 (USE_ANALOG_CHARGING_LEVELS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FVC_ALG_ENABLE                           = " "0 (FLOAT_VOLTAGE_CONTROL_ALGORITHM_DISABLED),1 (FLOAT_VOLTAGE_CONTROL_ALGORITHM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CCSOFTSTART_ALG_ENABLE                   = " "0 (CHARGE_CURRENT_SOFTSTART_ALGORITHM_DISABLED),1 (CHARGE_CURRENT_SOFTSTART_ALGORITHM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TERMINATION_ALG_ENABLE                   = " "0 (TERMINATION_ALGORITHM_DISABLED),1 (TERMINATION_ALGORITHM_ENABLED)"
    tree.end
    tree "SCHG8998_CHGR_ENG_SBQ_CFG1"
      sgroup "SCHG8998_CHGR_ENG_SBQ_CFG1 (at 0x10c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_SBQ_HVOV_CTRL_BATFET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENG_SBQ_BATT_R_DIVIDER                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_SBQ_TCTRL_I2C                        = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_CHGR_ENG_SBQ_CFG2"
      sgroup "SCHG8998_CHGR_ENG_SBQ_CFG2 (at 0x10c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_SBQ_FLT200B                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENG_SBQ_REF_SOFTL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENG_SBQ_TLLS_OTP                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_SBQ_IBIAS                            = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_TM_SBQ"
      sgroup "SCHG8998_CHGR_TM_SBQ (at 0x10e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TM_SBQ_TEMPLOOP                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TM_SBQ_BATFET                            = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_CHGR_TEST_EN_CFG"
      sgroup "SCHG8998_CHGR_TEST_EN_CFG (at 0x10e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TESTMODE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TEST_USE_EXT_CLK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TEST_INPUT_MUX_ENABLE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEST_OUTPUT_MUX_ENABLE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_REGISTER_PASS_THRU                  = " "0, 1"
    tree.end
    tree "SCHG8998_CHGR_TEST_ALL_MUX_SELECT"
      sgroup "SCHG8998_CHGR_TEST_ALL_MUX_SELECT (at 0x10e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TEST_ALL_MUX_SELECT                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_CHGR_TEST_OUTPUT_DRIVING"
      sgroup "SCHG8998_CHGR_TEST_OUTPUT_DRIVING (at 0x10e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TEST_OUTPUT_DRIVING                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_CHGR_TRIM_NUM"
      sgroup "SCHG8998_CHGR_TRIM_NUM (at 0x10f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_BATLOW"
      sgroup "SCHG8998_CHGR_TR_SBQ_BATLOW (at 0x10f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SBQ_BATLOW                            = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_VIRTUAL_DIODE_THRESHOLD"
      sgroup "SCHG8998_CHGR_TR_SBQ_VIRTUAL_DIODE_THRESHOLD (at 0x10f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SBQ_VIRTUAL_DIODE_THRESHOLD           = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_PRECHARGE"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_PRECHARGE (at 0x10f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SBQ_ICHG_GAIN_PRECHARGE               = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_LINEAR_LC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_LINEAR_LC (at 0x10f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SBQ_ICHG_GAIN_LINEAR_LC               = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_LINEAR_HC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_LINEAR_HC (at 0x10f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SBQ_ICHG_GAIN_LINEAR_HC               = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_FULLON_LC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_FULLON_LC (at 0x10f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SBQ_ICHG_GAIN_FULLON_LC               = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_FULLON_HC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_GAIN_FULLON_HC (at 0x10f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SBQ_ICHG_GAIN_FULLON_HC               = "
    tree.end
    tree "SCHG8998_CHGR_TR_FV_ADJUST"
      sgroup "SCHG8998_CHGR_TR_FV_ADJUST (at 0x10f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_FLOAT_VOLTAGE_ADJUSTMENT              = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_PRECHARGE"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_PRECHARGE (at 0x10f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_ICHG_OFFSET_PRECHARGE             = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_LINEAR_LC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_LINEAR_LC (at 0x10fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_ICHG_OFFSET_LINEAR_LC             = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_LINEAR_HC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_LINEAR_HC (at 0x10fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_ICHG_OFFSET_LINEAR_HC             = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_FULLON_LC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_FULLON_LC (at 0x10fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_ICHG_OFFSET_FULLON_LC             = "
    tree.end
    tree "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_FULLON_HC"
      sgroup "SCHG8998_CHGR_TR_SBQ_ICHG_OFFSET_FULLON_HC (at 0x10fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_ICHG_OFFSET_FULLON_HC             = "
    tree.end
  tree.end
tree.end
tree "SCHG8998_DC"
  tree "SCHG8998_DC"
    tree "SCHG8998_DC_PERPH_TYPE"
      sgroup "SCHG8998_DC_PERPH_TYPE (at 0x1404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SCHG8998_DC_PERPH_SUBTYPE"
      sgroup "SCHG8998_DC_PERPH_SUBTYPE (at 0x1405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SCHG8998_DC_CLOCK_STATUS"
      sgroup "SCHG8998_DC_CLOCK_STATUS (at 0x1409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLOCK_STATUS                             = " "0 (TRANSITION),1 (GATED_192MHZ),2 (CLK_200KHZ),3 (INVALID)"
    tree.end
    tree "SCHG8998_DC_SEC_ACCESS"
      sgroup "SCHG8998_DC_SEC_ACCESS (at 0x14d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SCHG8998_DC_PERPH_RESET_CTL2"
      sgroup "SCHG8998_DC_PERPH_RESET_CTL2 (at 0x14d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SCHG8998_DC_PERPH_RESET_CTL3"
      sgroup "SCHG8998_DC_PERPH_RESET_CTL3 (at 0x14da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SCHG8998_DC_PERPH_RESET_CTL4"
      sgroup "SCHG8998_DC_PERPH_RESET_CTL4 (at 0x14db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SCHG8998_DC_CLOCK_GATE"
      sgroup "SCHG8998_DC_CLOCK_GATE (at 0x14de)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014de0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14de0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PERFORM_GATING                           = " "0 (NO_CLOCK_GATING),1 (DO_CLOCK_GATING)"
    tree.end
    tree "SCHG8998_DC_CLOCK_CONTROL"
      sgroup "SCHG8998_DC_CLOCK_CONTROL (at 0x14df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RFU                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_CHICKEN_BIT                          = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USE_200K                                 = " "0 (USE_GATED_192MHZ),1 (USE_200KHZ)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CMD_CLK_19P2MHZ_REQUEST                  = " "0 (DONT_FORCE_CLK_REQUEST),1 (FORCE_CLK_REQUEST)"
    tree.end
    tree "SCHG8998_DC_DCIN_INPUT_STATUS"
      sgroup "SCHG8998_DC_DCIN_INPUT_STATUS (at 0x1406)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DCIN_INPUT_STATUS_7                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_INPUT_STATUS_6                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_12V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_9V_TO_12V                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_9V                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_5V_TO_12V                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_5V_TO_9V                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_5V                                  = " "0, 1"
    tree.end
    tree "SCHG8998_DC_WIPWR_STATUS"
      sgroup "SCHG8998_DC_WIPWR_STATUS (at 0x1407)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_STATUS_7                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WIPWR_STATUS_6                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WIPWR_STATUS_5                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_WIPWR_OV_DG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIV2_EN_DG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SHUTDOWN_N_LATCH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHG_OK_PIN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WIPWR_CHARGING_ENABLED                   = " "0, 1"
    tree.end
    tree "SCHG8998_DC_WIPWR_RANGE_STATUS"
      sgroup "SCHG8998_DC_WIPWR_RANGE_STATUS (at 0x1408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   WIPWR_RANGE_STATUS                       = "
    tree.end
    tree "SCHG8998_DC_INT_RT_STS"
      sgroup "SCHG8998_DC_INT_RT_STS (at 0x1410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_RT_STS                     = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_SET_TYPE"
      sgroup "SCHG8998_DC_INT_SET_TYPE (at 0x1411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_TYPE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_TYPE                       = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_POLARITY_HIGH"
      sgroup "SCHG8998_DC_INT_POLARITY_HIGH (at 0x1412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_HIGH                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_HIGH                       = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_POLARITY_LOW"
      sgroup "SCHG8998_DC_INT_POLARITY_LOW (at 0x1413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_LOW                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_LOW                        = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_LATCHED_CLR"
      sgroup "SCHG8998_DC_INT_LATCHED_CLR (at 0x1414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_LATCHED_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_LATCHED_CLR                = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_EN_SET"
      sgroup "SCHG8998_DC_INT_EN_SET (at 0x1415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_EN_SET               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_EN_SET                     = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_EN_CLR"
      sgroup "SCHG8998_DC_INT_EN_CLR (at 0x1416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_EN_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_EN_CLR                     = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_LATCHED_STS"
      sgroup "SCHG8998_DC_INT_LATCHED_STS (at 0x1418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_LATCHED_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_LATCHED_STS                = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_PENDING_STS"
      sgroup "SCHG8998_DC_INT_PENDING_STS (at 0x1419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_PENDING_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_PENDING_STS                = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_MID_SEL"
      sgroup "SCHG8998_DC_INT_MID_SEL (at 0x141a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_DC_INT_PRIORITY"
      sgroup "SCHG8998_DC_INT_PRIORITY (at 0x141b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_TEST1"
      sgroup "SCHG8998_DC_INT_TEST1 (at 0x14e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SCHG8998_DC_INT_TEST_VAL"
      sgroup "SCHG8998_DC_INT_TEST_VAL (at 0x14e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_VOLTAGE_RANGE_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_VAL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_VASHDN_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_VAL                        = " "0, 1"
    tree.end
    tree "SCHG8998_DC_CMD_IL"
      sgroup "SCHG8998_DC_CMD_IL (at 0x1440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIRELESS_CHG_DIS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SHDN_N_CLEAR_CMD                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SHDN_N_SET_CMD                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_SUSPEND                             = " "0, 1"
    tree.end
    tree "SCHG8998_DC_DCIN_ADAPTER_ALLOW_CFG"
      sgroup "SCHG8998_DC_DCIN_ADAPTER_ALLOW_CFG (at 0x1460)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DCIN_ADAPTER_ALLOW                       = "
    tree.end
    tree "SCHG8998_DC_DCIN_LOAD_CFG"
      sgroup "SCHG8998_DC_DCIN_LOAD_CFG (at 0x1465)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DCIN_OV_CH_LOAD_OPTION                   = " "0 (DO_NOT_DISABLE_DCIN_PATH_ON_USBIN_OV),1 (DISABLE_DCIN_PATH_ON_USBIN_OV)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DCIN_AICL_STEP_TIMING_SEL                = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DCIN_IN_COLLAPSE_GF_SEL                  = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_DC_DCIN_CURRENT_LIMIT_CFG"
      sgroup "SCHG8998_DC_DCIN_CURRENT_LIMIT_CFG (at 0x1470)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DCIN_CURRENT_LIMIT                       = "
    tree.end
    tree "SCHG8998_DC_DCIN_AICL_OPTIONS_CFG"
      sgroup "SCHG8998_DC_DCIN_AICL_OPTIONS_CFG (at 0x1480)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SUSPEND_ON_COLLAPSE_DCIN                 = " "0 (DCIN_DOES_NOT_SUSPEND_ON_COLLAPSE),1 (DCIN_SUSPENDS_ON_COLLAPSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_AICL_HDC_EN                         = " "0 (DCIN_AICL_HDC_DISABLED),1 (DCIN_AICL_HDC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_AICL_START_AT_MAX                   = " "0 (DCIN_AICL_DOES_NOT_START_AT_MAX),1 (DCIN_AICL_STARTS_AT_MAX)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_AICL_RERUN_EN                       = " "0 (DCIN_AICL_RERUN_DISABLED),1 (DCIN_AICL_RERUN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_AICL_ADC_EN                         = " "0 (DCIN_AICL_ADC_DISABLED),1 (DCIN_AICL_ADC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_AICL_EN                             = " "0 (DCIN_AICL_DISABLED),1 (DCIN_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_HV_COLLAPSE_RESPONSE                = " "0 (DCIN_COLLAPSE_HV_FET_ON),1 (DCIN_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_LV_COLLAPSE_RESPONSE                = " "0 (DCIN_COLLAPSE_LV_FET_ON),1 (DCIN_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SCHG8998_DC_DCIN_AICL_REF_SEL_CFG"
      sgroup "SCHG8998_DC_DCIN_AICL_REF_SEL_CFG (at 0x1481)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DCIN_CONT_AICL_THRESHOLD_CFG             = "
    tree.end
    tree "SCHG8998_DC_DCIN_ICL_START_CFG"
      sgroup "SCHG8998_DC_DCIN_ICL_START_CFG (at 0x1482)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_ICL_START_CFG                       = " "0 (DCIN_ICL_MIN_IS_25MA),1 (DCIN_ICL_MIN_IS_500MA)"
    tree.end
    tree "SCHG8998_DC_DIV2_EN_GF_TIME_CFG"
      sgroup "SCHG8998_DC_DIV2_EN_GF_TIME_CFG (at 0x1490)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV2_EN_GF_TIME_CFG                      = " "0 (DIV2_DG_0US),1 (DIV2_DG_150US),2 (DIV2_DG_250US),3 (DIV2_DG_500US)"
    tree.end
    tree "SCHG8998_DC_WIPWR_IRQ_TMR_CFG"
      sgroup "SCHG8998_DC_WIPWR_IRQ_TMR_CFG (at 0x1491)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WIPWR_IRQ_TMR                            = " "0 (WIPWR_IRQ_TMR_1P3S),1 (WIPWR_IRQ_TMR_1P95S),2 (WIPWR_IRQ_TMR_2P6S),3 (WIPWR_IRQ_TMR_3P25S),4 (WIPWR_IRQ_TMR_3P9S),5 (WIPWR_IRQ_TMR_4P55S),6 (WIPWR_IRQ_TMR_5P2S),7 (WIPWR_IRQ_TMR_5P85S)"
    tree.end
    tree "SCHG8998_DC_ZIN_ICL_PT"
      sgroup "SCHG8998_DC_ZIN_ICL_PT (at 0x1492)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_PT                               = "
    tree.end
    tree "SCHG8998_DC_ZIN_ICL_LV"
      sgroup "SCHG8998_DC_ZIN_ICL_LV (at 0x1493)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_LV                               = "
    tree.end
    tree "SCHG8998_DC_ZIN_ICL_HV"
      sgroup "SCHG8998_DC_ZIN_ICL_HV (at 0x1494)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_HV                               = "
    tree.end
    tree "SCHG8998_DC_WI_PWR_OPTIONS"
      sgroup "SCHG8998_DC_WI_PWR_OPTIONS (at 0x1495)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_OK                                   = " "0 (CHG_OK_DIS),1 (CHG_OK_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WIPWR_UVLO_IRQ_OPT                       = " "0 (CHG_OK_DEPENDENT),1 (CHG_OK_INDEPENDENT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BUCK_HOLDOFF_ENABLE                      = " "0 (WIPWR_BUCK_HOLDOFF_DIS),1 (WIPWR_BUCK_HOLDOFF_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHG_OK_HW_SW_SELECT                      = " "0 (CHG_OK_SW),1 (CHG_OK_HW)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_RST_ENABLE                         = " "0 (WIPWR_RST_DIS),1 (WIPWR_RST_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_WIPWR_IRQ_SELECT                    = " "0 (DCIN_IRQ_SEL),1 (WIPWR_IRQ_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_SWITCH_ENABLE                       = " "0 (WIPWR_AICL_SWITCH_DIS),1 (WIPWR_AICL_SWITCH_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZIN_ICL_ENABLE                           = " "0 (ICL_CHARGER_REGS),1 (ICL_WIPWR_REGS)"
    tree.end
    tree "SCHG8998_DC_ZIN_ICL_PT_HV"
      sgroup "SCHG8998_DC_ZIN_ICL_PT_HV (at 0x1496)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_PT_HV                            = "
    tree.end
    tree "SCHG8998_DC_ZIN_ICL_MID_LV"
      sgroup "SCHG8998_DC_ZIN_ICL_MID_LV (at 0x1497)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_MID_LV                           = "
    tree.end
    tree "SCHG8998_DC_ZIN_ICL_MID_HV"
      sgroup "SCHG8998_DC_ZIN_ICL_MID_HV (at 0x1498)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_MID_HV                           = "
    tree.end
    tree "SCHG8998_DC_ENG_SSUPPLY_CFG1"
      sgroup "SCHG8998_DC_ENG_SSUPPLY_CFG1 (at 0x14c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_SSUPPLY_12V_OV_OPT                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ENG_SSUPPLY_BB_CLMP_SEL                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENG_SSUPPLY_CFG_IIN_LMT_BYPASS           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_SSUPPLY_RESERVE1_NOT_USED            = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_DC_ENG_SSUPPLY_CFG2"
      sgroup "SCHG8998_DC_ENG_SSUPPLY_CFG2 (at 0x14c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENG_SSUPPLY_DIS_SSDONE_CTRL_MIDS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENG_SSUPPLY_SEL_5V_SYSON_LDO             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ENG_SSUPPLY_RESERVE2_NOT_USED            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ENG_SSUPPLY_IVREF_OTG_SS                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_DC_ENG_SSUPPLY_CFG3"
      sgroup "SCHG8998_DC_ENG_SSUPPLY_CFG3 (at 0x14c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENG_SSUPPLY_HI_CAP                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_SSUPPLY_HI_RES                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_SSUPPLY_CFG_SKIP_TH_V0P2             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENG_SSUPPLY_CFG_SYSOV_TH_4P8             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_SSUPPLY_5V_OV_OPT                    = " "0, 1"
    tree.end
    tree "SCHG8998_DC_TM_SSUPPLY"
      sgroup "SCHG8998_DC_TM_SSUPPLY (at 0x14e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_SSUPPLY_SOFTSTART                     = " "0, 1"
    tree.end
    tree "SCHG8998_DC_TRIM_NUM"
      sgroup "SCHG8998_DC_TRIM_NUM (at 0x14f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_DAC_OFFS"
      sgroup "SCHG8998_DC_TR_SSUPPLY_DAC_OFFS (at 0x14f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TR_SSUPPLY_POS_DACOFFS                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SSUPPLY_DAC_OFFS                      = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_IIN_REF_BUCK_HC"
      sgroup "SCHG8998_DC_TR_SSUPPLY_IIN_REF_BUCK_HC (at 0x14f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_IIN_REF_BUCK_HC               = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_IIN_REF_BUCK_LC"
      sgroup "SCHG8998_DC_TR_SSUPPLY_IIN_REF_BUCK_LC (at 0x14f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_IIN_REF_BUCK_LC               = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_IIN_REF_BOOST"
      sgroup "SCHG8998_DC_TR_SSUPPLY_IIN_REF_BOOST (at 0x14f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_IIN_REF_BOOST                 = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_PRECHARGE"
      sgroup "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_PRECHARGE (at 0x14f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_ICHG_REF_PRECHARGE            = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_LINEAR_LC"
      sgroup "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_LINEAR_LC (at 0x14f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_ICHG_REF_LINEAR_LC            = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_LINEAR_HC"
      sgroup "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_LINEAR_HC (at 0x14f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_ICHG_REF_LINEAR_HC            = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_FULLON_LC"
      sgroup "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_FULLON_LC (at 0x14f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_ICHG_REF_FULLON_LC            = "
    tree.end
    tree "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_FULLON_HC"
      sgroup "SCHG8998_DC_TR_SSUPPLY_ICHG_REF_FULLON_HC (at 0x14f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SSUPPLY_ICHG_REF_FULLON_HC            = "
    tree.end
  tree.end
tree.end
tree "SCHG8998_MISC"
  tree "SCHG8998_MISC"
    tree "SCHG8998_MISC_REVISION1"
      sgroup "SCHG8998_MISC_REVISION1 (at 0x1600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SCHG8998_MISC_REVISION2"
      sgroup "SCHG8998_MISC_REVISION2 (at 0x1601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SCHG8998_MISC_REVISION3"
      sgroup "SCHG8998_MISC_REVISION3 (at 0x1602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SCHG8998_MISC_REVISION4"
      sgroup "SCHG8998_MISC_REVISION4 (at 0x1603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SCHG8998_MISC_PERPH_TYPE"
      sgroup "SCHG8998_MISC_PERPH_TYPE (at 0x1604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SCHG8998_MISC_PERPH_SUBTYPE"
      sgroup "SCHG8998_MISC_PERPH_SUBTYPE (at 0x1605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SCHG8998_MISC_SEC_ACCESS"
      sgroup "SCHG8998_MISC_SEC_ACCESS (at 0x16d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SCHG8998_MISC_PERPH_RESET_CTL2"
      sgroup "SCHG8998_MISC_PERPH_RESET_CTL2 (at 0x16d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_PERPH_RESET_CTL3"
      sgroup "SCHG8998_MISC_PERPH_RESET_CTL3 (at 0x16da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_PERPH_RESET_CTL4"
      sgroup "SCHG8998_MISC_PERPH_RESET_CTL4 (at 0x16db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_SPARE"
      sgroup "SCHG8998_MISC_SPARE (at 0x16df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TEMP_RANGE_STATUS"
      sgroup "SCHG8998_MISC_TEMP_RANGE_STATUS (at 0x1606)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUCK_OC                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_REG_ACTIVE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TLIM                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALERT_LEVEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TEMP_ABOVE_RANGE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TEMP_WITHIN_RANGE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_BELOW_RANGE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERMREG_DISABLED                        = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_ICL_STATUS"
      sgroup "SCHG8998_MISC_ICL_STATUS (at 0x1607)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   INPUT_CURRENT_LIMIT                      = "
    tree.end
    tree "SCHG8998_MISC_ADAPTER_5V_ICL_STATUS"
      sgroup "SCHG8998_MISC_ADAPTER_5V_ICL_STATUS (at 0x1608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADAPTER_5V_ICL                           = "
    tree.end
    tree "SCHG8998_MISC_ADAPTER_9V_ICL_STATUS"
      sgroup "SCHG8998_MISC_ADAPTER_9V_ICL_STATUS (at 0x1609)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADAPTER_9V_ICL                           = "
    tree.end
    tree "SCHG8998_MISC_AICL_STATUS"
      sgroup "SCHG8998_MISC_AICL_STATUS (at 0x160a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80160a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x160a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AICL_STATUS_7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_ILIMIT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HIGHEST_DC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_CH_COLLAPSE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_CH_COLLAPSE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ICL_IMIN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_FAIL                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AICL_DONE                                = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_POWER_PATH_STATUS"
      sgroup "SCHG8998_MISC_POWER_PATH_STATUS (at 0x160b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80160b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x160b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_SS_DONE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_SUSPEND                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_SUSPEND                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USE_USBIN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USE_DCIN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   POWER_PATH                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VALID_INPUT_POWER_SOURCE                 = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_WDOG_STATUS"
      sgroup "SCHG8998_MISC_WDOG_STATUS (at 0x160c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80160c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x160c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WDOG_STATUS_7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WDOG_STATUS_6                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_STATUS_5                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WDOG_STATUS_4                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WDOG_STATUS_3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_STATUS_2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_STATUS_1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BARK_BITE_STATUS                         = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_SYSOK_REASON_STATUS"
      sgroup "SCHG8998_MISC_SYSOK_REASON_STATUS (at 0x160d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80160d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x160d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SYSOK_REASON_STATUS_7                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SYSOK_REASON_STATUS_6                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SYSOK_REASON_STATUS_5                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SYSOK_REASON_STATUS_4                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYSOK_REASON_STATUS_3                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SYSOK_REASON_STATUS_2                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYSOK_REASON_DCIN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYSOK_REASON_USBIN                       = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_RT_STS"
      sgroup "SCHG8998_MISC_INT_RT_STS (at 0x1610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_RT_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_RT_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_RT_STS                        = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_SET_TYPE"
      sgroup "SCHG8998_MISC_INT_SET_TYPE (at 0x1611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_TYPE                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_TYPE                          = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_POLARITY_HIGH"
      sgroup "SCHG8998_MISC_INT_POLARITY_HIGH (at 0x1612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_HIGH                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_HIGH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_HIGH                          = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_POLARITY_LOW"
      sgroup "SCHG8998_MISC_INT_POLARITY_LOW (at 0x1613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_LOW                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_LOW               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_LOW                           = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_LATCHED_CLR"
      sgroup "SCHG8998_MISC_INT_LATCHED_CLR (at 0x1614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_LATCHED_CLR       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_EN_SET"
      sgroup "SCHG8998_MISC_INT_EN_SET (at 0x1615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_EN_SET                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_EN_SET            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_EN_SET                        = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_EN_CLR"
      sgroup "SCHG8998_MISC_INT_EN_CLR (at 0x1616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_EN_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_EN_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_EN_CLR                        = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_LATCHED_STS"
      sgroup "SCHG8998_MISC_INT_LATCHED_STS (at 0x1618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_LATCHED_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_LATCHED_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_PENDING_STS"
      sgroup "SCHG8998_MISC_INT_PENDING_STS (at 0x1619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_PENDING_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_PENDING_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_PENDING_STS                   = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_MID_SEL"
      sgroup "SCHG8998_MISC_INT_MID_SEL (at 0x161a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_INT_PRIORITY"
      sgroup "SCHG8998_MISC_INT_PRIORITY (at 0x161b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_TEST1"
      sgroup "SCHG8998_MISC_INT_TEST1 (at 0x16e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_INT_TEST_VAL"
      sgroup "SCHG8998_MISC_INT_TEST_VAL (at 0x16e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_VAL               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_VAL                           = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_WDOG_RST"
      sgroup "SCHG8998_MISC_WDOG_RST (at 0x1640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_RST                                 = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_AFP_MODE"
      sgroup "SCHG8998_MISC_AFP_MODE (at 0x1641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AFP_MODE_EN                              = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_GSM_PA_ON_ADJ_EN"
      sgroup "SCHG8998_MISC_GSM_PA_ON_ADJ_EN (at 0x1642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GSM_PA_ON_ADJ_EN                         = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_BARK_BITE_WDOG_PET"
      sgroup "SCHG8998_MISC_BARK_BITE_WDOG_PET (at 0x1643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BARK_BITE_WDOG_PET                       = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_PHYON_CMD"
      sgroup "SCHG8998_MISC_PHYON_CMD (at 0x1644)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHYON_CMD                                = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_SHDN_CMD"
      sgroup "SCHG8998_MISC_SHDN_CMD (at 0x1645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SHDN_CMD                                 = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_FINISH_COPY_COMMAND"
      sgroup "SCHG8998_MISC_FINISH_COPY_COMMAND (at 0x164f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80164f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x164f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_COPY                               = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_WD_CFG"
      sgroup "SCHG8998_MISC_WD_CFG (at 0x1651)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WATCHDOG_TRIGGER_AFP_EN                  = " "0 (AFP_WDOG_DIS),1 (AFP_WDOG_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BARK_WDOG_INT_EN                         = " "0 (BARK_WDOG_INTR_DIS),1 (BARK_WDOG_INTR_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BITE_WDOG_INT_EN                         = " "0 (BITE_WDOG_INTR_DIS),1 (BITE_WDOG_INTR_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SFT_AFTER_WDOG_IRQ                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_IRQ_SFT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_TIMER_EN_ON_PLUGIN                  = " "0 (WDOG_DIS_ON_PLUGIN),1 (WDOG_EN_ON_PLUGIN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_TIMER_EN                            = " "0 (WDOG_DIS),1 (WDOG_EN)"
    tree.end
    tree "SCHG8998_MISC_MISC_CFG"
      sgroup "SCHG8998_MISC_MISC_CFG (at 0x1652)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TYPEC_CHICKEN_BIT                        = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STAT_PARALLEL_1400MA_EN_CFG              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GSM_PA_ON_ADJ_SEL                        = " "0 (PA_ON_DIS),1 (PA_ON_EN)"
    tree.end
    tree "SCHG8998_MISC_SNARL_BARK_BITE_WD_CFG"
      sgroup "SCHG8998_MISC_SNARL_BARK_BITE_WD_CFG (at 0x1653)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BITE_WDOG_DISABLE_CHARGING_CFG           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   SNARL_WDOG_TIMEOUT                       = " "0 (SNARL_WDOG_TMOUT_62P5MS),1 (SNARL_WDOG_TMOUT_125MS),2 (SNARL_WDOG_TMOUT_250MS),3 (SNARL_WDOG_TMOUT_500MS),4 (SNARL_WDOG_TMOUT_1S),5 (SNARL_WDOG_TMOUT_2S),6 (SNARL_WDOG_TMOUT_4S),7 (SNARL_WDOG_TMOUT_8S)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BARK_WDOG_TIMEOUT                        = " "0 (BARK_WDOG_TMOUT_16S),1 (BARK_WDOG_TMOUT_32S),2 (BARK_WDOG_TMOUT_64S),3 (BARK_WDOG_TMOUT_128S)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BITE_WDOG_TIMEOUT                        = " "0 (BITE_WDOG_TMOUT_1S),1 (BITE_WDOG_TMOUT_2S),2 (BITE_WDOG_TMOUT_4S),3 (BITE_WDOG_TMOUT_8S)"
    tree.end
    tree "SCHG8998_MISC_PHYON_CFG"
      sgroup "SCHG8998_MISC_PHYON_CFG (at 0x1654)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBPHYON_PUSHPULL_CFG                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHYON_SW_SEL                             = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_CHGR_TRIM_OPTIONS_7_0"
      sgroup "SCHG8998_MISC_CHGR_TRIM_OPTIONS_7_0 (at 0x1655)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TLIM_DIS_TBIT                            = " "0 (TLIM_EN),1 (TLIM_DIS)"
    tree.end
    tree "SCHG8998_MISC_CH_OV_OPTION_CFG"
      sgroup "SCHG8998_MISC_CH_OV_OPTION_CFG (at 0x1656)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OV_OPTION_TBIT                           = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_AICL_CFG"
      sgroup "SCHG8998_MISC_AICL_CFG (at 0x1660)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_BLOCK_HDC                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TREG_ALLOW_DECREASE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AICL_HIGH_DC_INC                         = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_AICL_RERUN_TIME_CFG"
      sgroup "SCHG8998_MISC_AICL_RERUN_TIME_CFG (at 0x1661)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AICL_RERUN_TIME                          = " "0 (AICL_RERUN_TIME_3S),1 (AICL_RERUN_TIME_12S),2 (AICL_RERUN_TIME_45S),3 (AICL_RERUN_TIME_3MIN)"
    tree.end
    tree "SCHG8998_MISC_AICL_RERUN_TEMP_TIME_CFG"
      sgroup "SCHG8998_MISC_AICL_RERUN_TEMP_TIME_CFG (at 0x1662)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AICL_RERUN_TEMP_TIME                     = " "0 (AICL_RERUN_TEMP_TIME_0P2S),1 (AICL_RERUN_TEMP_TIME_0P4S),2 (AICL_RERUN_TEMP_TIME_0P8S),3 (AICL_RERUN_TEMP_TIME_1P6S)"
    tree.end
    tree "SCHG8998_MISC_THERMREG_SRC_CFG"
      sgroup "SCHG8998_MISC_THERMREG_SRC_CFG (at 0x1670)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALLOW_ALL_DIE_CMP_SRC                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SKIN_ADC_CFG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   THERMREG_SKIN_ADC_SRC_EN                 = " "0 (THERMAL_REG_SKIN_ADC_DIS),1 (THERMAL_REG_SKIN_ADC_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   THERMREG_DIE_ADC_SRC_EN                  = " "0 (THERMAL_REG_DIE_ADC_DIS),1 (THERMAL_REG_DIE_ADC_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERMREG_DIE_CMP_SRC_EN                  = " "0 (THERMAL_REG_DIE_CMP_DIS),1 (THERMAL_REG_DIE_CMP_EN)"
    tree.end
    tree "SCHG8998_MISC_TREG_DIE_CMP_INC_CYCLE_TIME_CFG"
      sgroup "SCHG8998_MISC_TREG_DIE_CMP_INC_CYCLE_TIME_CFG (at 0x1671)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_CMP_INC_CYCLE_TIME              = " "0 (TREG_DIE_CMP_INC_CYCLE_TIME_0P2S),1 (TREG_DIE_CMP_INC_CYCLE_TIME_0P4S),2 (TREG_DIE_CMP_INC_CYCLE_TIME_0P8S),3 (TREG_DIE_CMP_INC_CYCLE_TIME_1P6S)"
    tree.end
    tree "SCHG8998_MISC_TREG_DIE_CMP_DEC_CYCLE_TIME_CFG"
      sgroup "SCHG8998_MISC_TREG_DIE_CMP_DEC_CYCLE_TIME_CFG (at 0x1672)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_CMP_DEC_CYCLE_TIME              = " "0 (TREG_DIE_CMP_DEC_CYCLE_TIME_0P2S),1 (TREG_DIE_CMP_DEC_CYCLE_TIME_0P4S),2 (TREG_DIE_CMP_DEC_CYCLE_TIME_0P8S),3 (TREG_DIE_CMP_DEC_CYCLE_TIME_1P6S)"
    tree.end
    tree "SCHG8998_MISC_TREG_DIE_ADC_INC_CYCLE_TIME_CFG"
      sgroup "SCHG8998_MISC_TREG_DIE_ADC_INC_CYCLE_TIME_CFG (at 0x1673)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_ADC_INC_CYCLE_TIME              = " "0 (TREG_DIE_ADC_INC_CYCLE_TIME_2S),1 (TREG_DIE_ADC_INC_CYCLE_TIME_4S),2 (TREG_DIE_ADC_INC_CYCLE_TIME_6S),3 (TREG_DIE_ADC_INC_CYCLE_TIME_8S)"
    tree.end
    tree "SCHG8998_MISC_TREG_DIE_ADC_DEC_CYCLE_TIME_CFG"
      sgroup "SCHG8998_MISC_TREG_DIE_ADC_DEC_CYCLE_TIME_CFG (at 0x1674)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_ADC_DEC_CYCLE_TIME              = " "0 (TREG_DIE_ADC_DEC_CYCLE_TIME_2S),1 (TREG_DIE_ADC_DEC_CYCLE_TIME_4S),2 (TREG_DIE_ADC_DEC_CYCLE_TIME_6S),3 (TREG_DIE_ADC_DEC_CYCLE_TIME_8S)"
    tree.end
    tree "SCHG8998_MISC_TREG_SKIN_ADC_INC_CYCLE_TIME_CFG"
      sgroup "SCHG8998_MISC_TREG_SKIN_ADC_INC_CYCLE_TIME_CFG (at 0x1675)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_SKIN_ADC_INC_CYCLE_TIME             = " "0 (TREG_SKIN_ADC_INC_CYCLE_TIME_2S),1 (TREG_SKIN_ADC_INC_CYCLE_TIME_4S),2 (TREG_SKIN_ADC_INC_CYCLE_TIME_6S),3 (TREG_SKIN_ADC_INC_CYCLE_TIME_8S)"
    tree.end
    tree "SCHG8998_MISC_TREG_SKIN_ADC_DEC_CYCLE_TIME_CFG"
      sgroup "SCHG8998_MISC_TREG_SKIN_ADC_DEC_CYCLE_TIME_CFG (at 0x1676)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_SKIN_ADC_DEC_CYCLE_TIME             = " "0 (TREG_SKIN_ADC_DEC_CYCLE_TIME_2S),1 (TREG_SKIN_ADC_DEC_CYCLE_TIME_4S),2 (TREG_SKIN_ADC_DEC_CYCLE_TIME_6S),3 (TREG_SKIN_ADC_DEC_CYCLE_TIME_8S)"
    tree.end
    tree "SCHG8998_MISC_BUCK_OPTIONS_CFG"
      sgroup "SCHG8998_MISC_BUCK_OPTIONS_CFG (at 0x1680)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUCK_OC_DG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_EN_PIN_SUSPEND_CFG                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HICCUP_OPTIONS                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INPUT_CURRENT_LIMIT_SOFTSTART_EN         = " "0 (INPUT_CURRENT_LIMIT_SOFTSTART_DIS),1 (INPUT_CURRENT_LIMIT_SOFTSTART_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HV_HIGH_DUTY_CYCLE_PROTECT_EN            = " "0 (HV_HIGH_DUTY_CYCLE_PROTECT_DIS),1 (HV_HIGH_DUTY_CYCLE_PROTECT_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BUCK_OC_PROTECT_EN                       = " "0 (BUCK_OC_PROTECT_DIS),1 (BUCK_OC_PROTECT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INPUT_MISS_POLL_EN                       = " "0 (INPUT_MISSING_POLLER_DIS),1 (INPUT_MISSING_POLLER_EN)"
    tree.end
    tree "SCHG8998_MISC_ICL_SOFTSTART_RATE_CFG"
      sgroup "SCHG8998_MISC_ICL_SOFTSTART_RATE_CFG (at 0x1681)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ICL_SOFTSTART_RATE                       = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_ICL_SOFTSTOP_RATE_CFG"
      sgroup "SCHG8998_MISC_ICL_SOFTSTOP_RATE_CFG (at 0x1682)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ICL_SOFTSTOP_RATE                        = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_VSYS_MIN_SEL_CFG"
      sgroup "SCHG8998_MISC_VSYS_MIN_SEL_CFG (at 0x1683)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VSYS_MIN_SEL                             = " "0 (SYSMIN_3P2),1 (SYSMIN_3P4),2 (SYSMIN_3P6),3 (SYSMIN_3P8)"
    tree.end
    tree "SCHG8998_MISC_TRACKING_VOLTAGE_SEL_CFG"
      sgroup "SCHG8998_MISC_TRACKING_VOLTAGE_SEL_CFG (at 0x1684)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRACKING_VOLTAGE_SEL                     = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_STAT_CFG"
      sgroup "SCHG8998_MISC_STAT_CFG (at 0x1690)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAT_SW_OVERRIDE_VALUE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   STAT_SW_OVERRIDE_CFG                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   STAT_PARALLEL_OFF_DG_CFG                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STAT_POLARITY_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STAT_PARALLEL_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STAT_FUNCTION_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAT_IRQ_PULSING_EN                      = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_LBC_EN_CFG"
      sgroup "SCHG8998_MISC_LBC_EN_CFG (at 0x1691)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LBC_DURING_CHARGING_CFG                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LBC_EN                                   = " "0 (INPUT_MISSING_POLLER_DIS),1 (INPUT_MISSING_POLLER_EN)"
    tree.end
    tree "SCHG8998_MISC_LBC_PERIOD_CFG"
      sgroup "SCHG8998_MISC_LBC_PERIOD_CFG (at 0x1692)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LBC_PERIOD                               = " "0 (LBC_PERIOD_500MS),1 (LBC_PERIOD_1000MS),2 (LBC_PERIOD_1500MS),3 (LBC_PERIOD_2000MS),4 (LBC_PERIOD_2500MS),5 (LBC_PERIOD_3000MS),6 (LBC_PERIOD_3500MS),7 (LBC_PERIOD_4000MS)"
    tree.end
    tree "SCHG8998_MISC_LBC_DUTY_CYCLE_CFG"
      sgroup "SCHG8998_MISC_LBC_DUTY_CYCLE_CFG (at 0x1693)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LBC_DUTY_CYCLE                           = " "0 (LBC_DUTY_CYCLE_0PCT),1 (LBC_DUTY_CYCLE_12P5PCT),2 (LBC_DUTY_CYCLE_25PCT),3 (LBC_DUTY_CYCLE_37P5PCT),4 (LBC_DUTY_CYCLE_50PCT),5 (LBC_DUTY_CYCLE_62P5PCT),6 (LBC_DUTY_CYCLE_75PCT),7 (LBC_DUTY_CYCLE_100PCT)"
    tree.end
    tree "SCHG8998_MISC_SYSOK_CFG"
      sgroup "SCHG8998_MISC_SYSOK_CFG (at 0x1694)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SYSOK_PUSHPULL_CFG                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SYSOK_B_OR_C_SEL                         = " "0 (SYSOK_OPT_B),1 (SYSOK_OPT_C)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYSOK_POL                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SYSOK_OPTIONS                            = " "0 (INOK_OPT_1),1 (INOK_OPT_2),2 (SYSOK_OPT_A_1),3 (SYSOK_OPT_A_2),4 (SYSOK_OPT_BC_1),5 (SYSOK_OPT_BC_2),6 (CHG_DET_OPT_1),7 (CHG_DET_OPT_2)"
    tree.end
    tree "SCHG8998_MISC_CFG_BUCKBOOST_FREQ_SELECT_BUCK"
      sgroup "SCHG8998_MISC_CFG_BUCKBOOST_FREQ_SELECT_BUCK (at 0x16a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_BUCKBOOST_FREQ_SELECT_BUCK           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_CFG_BUCKBOOST_FREQ_SELECT_BOOST"
      sgroup "SCHG8998_MISC_CFG_BUCKBOOST_FREQ_SELECT_BOOST (at 0x16a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_BUCKBOOST_FREQ_SELECT_BOOST          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_CFG_SSUPPLY_VBOOST"
      sgroup "SCHG8998_MISC_CFG_SSUPPLY_VBOOST (at 0x16a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SSUPPLY_VBOOST                       = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_CFG_SBQ_DIE_TEMP_SENSOR_ADJ"
      sgroup "SCHG8998_MISC_CFG_SBQ_DIE_TEMP_SENSOR_ADJ (at 0x16a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_SBQ_DIE_TEMP_SENSOR_ADJ              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG1"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG1 (at 0x16c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENG_BUCKBOOST_8OR32B                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENG_BUCKBOOST_DISABLE_BOOT_UVLO_FOR_ALL  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_BUCKBOOST_DISABLE_CONT_REFRSH        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_BUCKBOOST_DISABLE_SLOPECOMP          = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ENG_BUCKBOOST_DCDC_OPTION                = "
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG2"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG2 (at 0x16c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENG_BUCKBOOST_DISABLE_SKIP               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENG_BUCKBOOST_DISABLE_SKIP_DLY_FOR_HS    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_BUCKBOOST_DISABLE_EXTENDED_SYNC      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_BUCKBOOST_DISABLE_SYSOV              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_BUCKBOOST_DISABLE_ZERO_DETECT        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ENG_BUCKBOOST_DUTY                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG3"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG3 (at 0x16c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENG_BUCKBOOST_ENABLE_FREQFOLD            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENG_BUCKBOOST_ENABLE_LSDRV               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_BUCKBOOST_ENABLE_LSFET_DURING_SOFTSTART = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_BUCKBOOST_FORCE_PWM_USB1             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_BUCKBOOST_INC_BOOT_UVLO_800MV        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ENG_BUCKBOOST_IPEAK_OTG_SELECT           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG4"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG4 (at 0x16c3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENG_BUCKBOOST_LONG_REFRESH               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_BUCKBOOST_LORAMP                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_BUCKBOOST_VSYS_REG_OPTION            = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ENG_BUCKBOOST_LOOP_OPTIONS               = "
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG5"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG5 (at 0x16c4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_BUCKBOOST_SKIP_DB_CFG                = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_BUCKBOOST_ENABLE_COMP_VCLAMP_USBIN   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_BUCKBOOST_ENABLE_COMP_VCLAMP_DCIN    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_BUCKBOOST_ENABLE_COMP_VCLAMP_OTG     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENG_BUCKBOOST_DISABLE_BOOT_UVLO_USBIN    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENG_BUCKBOOST_DISABLE_BOOT_UVLO_DCIN     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_BUCKBOOST_DISABLE_BOOT_UVLO_OTG      = " "0, 1"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG6"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG6 (at 0x16c5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ENG_BUCKBOOST_FALLING_SW_DEAD_TIME_USBIN = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENG_BUCKBOOST_FALLING_SW_DEAD_TIME_DCIN  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_BUCKBOOST_FALLING_SW_DEAD_TIME_OTG   = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG7"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG7 (at 0x16c6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ENG_BUCKBOOST_RISING_SW_DEAD_TIME_USBIN  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENG_BUCKBOOST_RISING_SW_DEAD_TIME_DCIN   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_BUCKBOOST_RISING_SW_DEAD_TIME_OTG    = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG8"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG8 (at 0x16c7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_BUCKBOOST_BST_BW                     = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_CFG9"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_CFG9 (at 0x16c8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   ENG_BUCKBOOST_IPEAK_DC_SELECT            = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ENG_BUCKBOOST_IPEAK_USB_SELECT           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_ENG_BUCKBOOST_SOFTSTART"
      sgroup "SCHG8998_MISC_ENG_BUCKBOOST_SOFTSTART (at 0x16c9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENG_SOFTSTART_BUCK_V_SELECT              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_SOFTSTART_OTG_V_SELECT               = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TM_IO_ATEST1_SEL"
      sgroup "SCHG8998_MISC_TM_IO_ATEST1_SEL (at 0x16e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_ATEST1_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_TM_IO_ATEST2_SEL"
      sgroup "SCHG8998_MISC_TM_IO_ATEST2_SEL (at 0x16e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_ATEST2_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_TM_IO_ATEST3_SEL"
      sgroup "SCHG8998_MISC_TM_IO_ATEST3_SEL (at 0x16e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_ATEST3_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_TM_IO_ATEST4_SEL"
      sgroup "SCHG8998_MISC_TM_IO_ATEST4_SEL (at 0x16e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_ATEST4_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_TM_IO_DTEST1_SEL"
      sgroup "SCHG8998_MISC_TM_IO_DTEST1_SEL (at 0x16e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_DTEST1_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_TM_IO_DTEST2_SEL"
      sgroup "SCHG8998_MISC_TM_IO_DTEST2_SEL (at 0x16e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_DTEST2_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_TM_IO_DTEST3_SEL"
      sgroup "SCHG8998_MISC_TM_IO_DTEST3_SEL (at 0x16e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_DTEST3_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_TM_IO_DTEST4_SEL"
      sgroup "SCHG8998_MISC_TM_IO_DTEST4_SEL (at 0x16e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_IO_DTEST4_SEL                         = "
    tree.end
    tree "SCHG8998_MISC_DTEST_SEL_EXT"
      sgroup "SCHG8998_MISC_DTEST_SEL_EXT (at 0x16ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DTEST4_SEL_EXT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DTEST3_SEL_EXT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DTEST2_SEL_EXT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST1_SEL_EXT                           = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TM_BUCKBOOST"
      sgroup "SCHG8998_MISC_TM_BUCKBOOST (at 0x16eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TM_BUCKBOOST_USBIN_IPEAK_FET_ON          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TM_BUCKBOOST_LSFET_ON                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_BUCKBOOST_HSFET_OFF                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_BUCKBOOST_HSFET_ON                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_BUCKBOOST_IPEAK_USBIN                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TM_BUCKBOOST_LOOP_DISABLES               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_TRIM_NUM"
      sgroup "SCHG8998_MISC_TRIM_NUM (at 0x16f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_BLANK_TIME"
      sgroup "SCHG8998_MISC_TR_SDCDC_BLANK_TIME (at 0x16f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SDCDC_BLANK_TIME                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_OTG_ISNS"
      sgroup "SCHG8998_MISC_TR_SDCDC_OTG_ISNS (at 0x16f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_OTG_ISNS                        = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_OSC"
      sgroup "SCHG8998_MISC_TR_SDCDC_OSC (at 0x16f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SDCDC_OSC                             = "
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_BUCK"
      sgroup "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_BUCK (at 0x16f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_SLOPE_COMP_BUCK                 = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_BOOST"
      sgroup "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_BOOST (at 0x16f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_SLOPE_COMP_BOOST                = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_FINE_BUCK"
      sgroup "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_FINE_BUCK (at 0x16f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_SLOPE_COMP_FINE_BUCK            = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_FINE_BOOST"
      sgroup "SCHG8998_MISC_TR_SDCDC_SLOPE_COMP_FINE_BOOST (at 0x16f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_SLOPE_COMP_FINE_BOOST           = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_USBIN_ISNS"
      sgroup "SCHG8998_MISC_TR_SDCDC_USBIN_ISNS (at 0x16f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_USBIN_ISNS                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_USBIN_IPEAK"
      sgroup "SCHG8998_MISC_TR_SDCDC_USBIN_IPEAK (at 0x16f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_USBIN_IPEAK                     = "
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_DCIN_ISNS"
      sgroup "SCHG8998_MISC_TR_SDCDC_DCIN_ISNS (at 0x16fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_DCIN_ISNS                       = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_MISC_TR_SDCDC_ZERO_DETECT"
      sgroup "SCHG8998_MISC_TR_SDCDC_ZERO_DETECT (at 0x16fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SDCDC_ZERO_DETECT                     = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "SCHG8998_OTG"
  tree "SCHG8998_OTG"
    tree "SCHG8998_OTG_PERPH_TYPE"
      sgroup "SCHG8998_OTG_PERPH_TYPE (at 0x1104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SCHG8998_OTG_PERPH_SUBTYPE"
      sgroup "SCHG8998_OTG_PERPH_SUBTYPE (at 0x1105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SCHG8998_OTG_SEC_ACCESS"
      sgroup "SCHG8998_OTG_SEC_ACCESS (at 0x11d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SCHG8998_OTG_PERPH_RESET_CTL2"
      sgroup "SCHG8998_OTG_PERPH_RESET_CTL2 (at 0x11d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_PERPH_RESET_CTL3"
      sgroup "SCHG8998_OTG_PERPH_RESET_CTL3 (at 0x11da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_PERPH_RESET_CTL4"
      sgroup "SCHG8998_OTG_PERPH_RESET_CTL4 (at 0x11db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_SPARE"
      sgroup "SCHG8998_OTG_SPARE (at 0x11df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTG_RID_CC_CONTROL_23_16"
      sgroup "SCHG8998_OTG_RID_CC_CONTROL_23_16 (at 0x1106)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RID_CC_CONTROL_23                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VCONN_SOFTSTART_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VCONN_SFTST_CFG                          = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CONNECT_RIDCC_SENSOR_TO_CC               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_CC_1P1CLAMP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_CRUDESEN_CC_1                     = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_RID_CC_CONTROL_15_8"
      sgroup "SCHG8998_OTG_RID_CC_CONTROL_15_8 (at 0x1107)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_CRUDESEN_CC_0                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   EN_FMB_2P5UA_CC                          = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_ISRC_180UA                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENABLE_CURRENTSOURCE_CC                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_BANDGAP_RID_C_DET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_RD_CC_1                           = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_RID_CC_CONTROL_7_0"
      sgroup "SCHG8998_OTG_RID_CC_CONTROL_7_0 (at 0x1108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RD_CC_0                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VCONN_ILIM500MA                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_MICRO_USB_MODE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UFP_DFP_MODE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VCONN_EN_CC                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREF_SEL_RIDCC_SENSOR                    = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTG_OTG_STATUS"
      sgroup "SCHG8998_OTG_OTG_STATUS (at 0x1109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BOOST_SOFTSTART_DONE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   OTG_STATE                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_OTG_INT_RT_STS"
      sgroup "SCHG8998_OTG_INT_RT_STS (at 0x1110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_RT_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_RT_STS                          = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_SET_TYPE"
      sgroup "SCHG8998_OTG_INT_SET_TYPE (at 0x1111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_TYPE             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_TYPE                            = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_POLARITY_HIGH"
      sgroup "SCHG8998_OTG_INT_POLARITY_HIGH (at 0x1112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_HIGH             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_HIGH                            = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_POLARITY_LOW"
      sgroup "SCHG8998_OTG_INT_POLARITY_LOW (at 0x1113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_LOW              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LOW                             = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_LATCHED_CLR"
      sgroup "SCHG8998_OTG_INT_LATCHED_CLR (at 0x1114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_LATCHED_CLR      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_EN_SET"
      sgroup "SCHG8998_OTG_INT_EN_SET (at 0x1115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_EN_SET           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_EN_SET                          = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_EN_CLR"
      sgroup "SCHG8998_OTG_INT_EN_CLR (at 0x1116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_EN_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_EN_CLR                          = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_LATCHED_STS"
      sgroup "SCHG8998_OTG_INT_LATCHED_STS (at 0x1118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_LATCHED_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_PENDING_STS"
      sgroup "SCHG8998_OTG_INT_PENDING_STS (at 0x1119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_DETECT_PENDING_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_MID_SEL"
      sgroup "SCHG8998_OTG_INT_MID_SEL (at 0x111a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x80111a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x111a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTG_INT_PRIORITY"
      sgroup "SCHG8998_OTG_INT_PRIORITY (at 0x111b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x80111b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x111b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_TEST1"
      sgroup "SCHG8998_OTG_INT_TEST1 (at 0x11e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_INT_TEST_VAL"
      sgroup "SCHG8998_OTG_INT_TEST_VAL (at 0x11e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_MITIGATION_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_VAL                             = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_CMD_OTG"
      sgroup "SCHG8998_OTG_CMD_OTG (at 0x1140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_EN                                   = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_BAT_UVLO_THRESHOLD_CFG"
      sgroup "SCHG8998_OTG_BAT_UVLO_THRESHOLD_CFG (at 0x1151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_UVLO_THRESHOLD                       = " "0 (OTG_BATTUV_2P7),1 (OTG_BATTUV_2P9),2 (OTG_BATTUV_3P1),3 (OTG_BATTUV_3P3)"
    tree.end
    tree "SCHG8998_OTG_OTG_CURRENT_LIMIT_CFG"
      sgroup "SCHG8998_OTG_OTG_CURRENT_LIMIT_CFG (at 0x1152)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   OTG_CURRENT_LIMIT                        = " "0 (OTG_ILIMIT_250MA),1 (OTG_ILIMIT_500MA),2 (OTG_ILIMIT_750MA),3 (OTG_ILIMIT_1000MA),4 (OTG_ILIMIT_1250MA),5 (OTG_ILIMIT_1500MA),6 (OTG_ILIMIT_1750MA),7 (OTG_ILIMIT_2000MA)"
    tree.end
    tree "SCHG8998_OTG_OTG_CFG"
      sgroup "SCHG8998_OTG_OTG_CFG (at 0x1153)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OTG_RESERVED                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIS_OTG_ON_TLIM                          = " "0 (EN_OTG_ON_TLIM),1 (DIS_OTG_ON_TLIM)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QUICKSTART_OTG_FASTROLESWAP              = " "0 (NO_QUICKSTART_OTG_FASTROLESWAP),1 (QUICKSTART_OTG_FASTROLESWAP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INCREASE_DFP_TIME                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENABLE_OTG_IN_DEBUG_MODE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_EN_SRC_CFG                           = " "0 (OTG_ENABLE_SRC_CMD),1 (OTG_ENABLE_SRC_TYPEC)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONCURRENT_MODE_CFG                      = " "0 (OTG_CONCURRENT_DIS),1 (OTG_CONCURRENT_EN)"
    tree.end
    tree "SCHG8998_OTG_FLASH_MITIGATION"
      sgroup "SCHG8998_OTG_FLASH_MITIGATION (at 0x1154)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FLASH_MITIGATION_CFG                     = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTG_ENG_OTG_CFG"
      sgroup "SCHG8998_OTG_ENG_OTG_CFG (at 0x11c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENG_BUCKBOOST_DIS_FIXED_DLY_FOR_BUCKBOOST = " "0 (BUCKBOOST_DIS_FIXED_DLY_FOR_BUCKBOOST_0),1 (BUCKBOOST_DIS_FIXED_DLY_FOR_BUCKBOOST_1)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ENG_BUCKBOOST_CBOOTUVLO_CTRL_BT          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   ENG_BUCKBOOST_CBOOTUVLO_CTRL_DRVL5       = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_BUCKBOOST_HALT1_8_MODE               = " "0 (ENG_BUCKBOOST_HALT1_8_MODE_DIS),1 (ENG_BUCKBOOST_HALT1_8_MODE_EN)"
    tree.end
    tree "SCHG8998_OTG_TM_OTG"
      sgroup "SCHG8998_OTG_TM_OTG (at 0x11e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TM_OTG_FAULT_SOURCE_DISABLE              = "
    tree.end
    tree "SCHG8998_OTG_CHG_IN_TEST_7_0"
      sgroup "SCHG8998_OTG_CHG_IN_TEST_7_0 (at 0x11e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_IN_TEST_7_0                          = "
    tree.end
    tree "SCHG8998_OTG_CHG_IN_TEST_15_8"
      sgroup "SCHG8998_OTG_CHG_IN_TEST_15_8 (at 0x11e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_IN_TEST_15_8                         = "
    tree.end
    tree "SCHG8998_OTG_CHG_IN_TEST_23_16"
      sgroup "SCHG8998_OTG_CHG_IN_TEST_23_16 (at 0x11e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_IN_TEST_23_16                        = "
    tree.end
    tree "SCHG8998_OTG_CHG_IN_TEST_31_24"
      sgroup "SCHG8998_OTG_CHG_IN_TEST_31_24 (at 0x11e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_IN_TEST_31_24                        = "
    tree.end
    tree "SCHG8998_OTG_TM_IO_STDBYOSC"
      sgroup "SCHG8998_OTG_TM_IO_STDBYOSC (at 0x11e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_IO_STDBYOSC                           = " "0, 1"
    tree.end
    tree "SCHG8998_OTG_TM_ISENSE"
      sgroup "SCHG8998_OTG_TM_ISENSE (at 0x11ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_ISENSE_EN_ATEST_DCIN                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_ISENSE_EN_ATEST_USBIN                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TM_ISENSE_ATEST_SEL                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_OTG_TRIM_NUM"
      sgroup "SCHG8998_OTG_TRIM_NUM (at 0x11f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SCHG8998_OTG_TR_IO_STDBYOSC_MAIN"
      sgroup "SCHG8998_OTG_TR_IO_STDBYOSC_MAIN (at 0x11f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_IO_STDBYOSC_MAIN                      = "
    tree.end
    tree "SCHG8998_OTG_TR_IO_STDBYOSC_TEMP"
      sgroup "SCHG8998_OTG_TR_IO_STDBYOSC_TEMP (at 0x11f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IO_STDBYOSC_TEMP                      = "
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_LOW_CURR1"
      sgroup "SCHG8998_OTG_TR_ISENSE_LOW_CURR1 (at 0x11f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_ISENSE_LOW_CURR1                      = "
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_DCIN_SNS"
      sgroup "SCHG8998_OTG_TR_ISENSE_DCIN_SNS (at 0x11f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_ISENSE_DCIN_SNS                       = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_LOW_CURR2"
      sgroup "SCHG8998_OTG_TR_ISENSE_LOW_CURR2 (at 0x11f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_ISENSE_LOW_CURR2                      = "
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_VREF_SEL"
      sgroup "SCHG8998_OTG_TR_ISENSE_VREF_SEL (at 0x11f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_ISENSE_VREF_SEL                       = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_USBIN"
      sgroup "SCHG8998_OTG_TR_ISENSE_USBIN (at 0x11f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_ISENSE_USBIN                          = "
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_DCIN"
      sgroup "SCHG8998_OTG_TR_ISENSE_DCIN (at 0x11f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_ISENSE_DCIN                           = "
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_CHRG_TEMP"
      sgroup "SCHG8998_OTG_TR_ISENSE_CHRG_TEMP (at 0x11f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_ISENSE_CHRG_TEMP                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_DCHRG_TEMP"
      sgroup "SCHG8998_OTG_TR_ISENSE_DCHRG_TEMP (at 0x11fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_ISENSE_DCHRG_TEMP                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_CHRG_G"
      sgroup "SCHG8998_OTG_TR_ISENSE_CHRG_G (at 0x11fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_ISENSE_CHRG_G                         = "
    tree.end
    tree "SCHG8998_OTG_TR_ISENSE_DCHRG_G"
      sgroup "SCHG8998_OTG_TR_ISENSE_DCHRG_G (at 0x11fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_ISENSE_DCHRG_G                        = "
    tree.end
  tree.end
tree.end
tree "SCHG8998_OTP_HDR"
  tree "SCHG8998_OTP_HDR"
    tree "SCHG8998_OTP_HDR_REVISION1"
      sgroup "SCHG8998_OTP_HDR_REVISION1 (at 0x1800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SCHG8998_OTP_HDR_REVISION2"
      sgroup "SCHG8998_OTP_HDR_REVISION2 (at 0x1801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SCHG8998_OTP_HDR_PERPH_TYPE"
      sgroup "SCHG8998_OTP_HDR_PERPH_TYPE (at 0x1804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SCHG8998_OTP_HDR_PERPH_SUBTYPE"
      sgroup "SCHG8998_OTP_HDR_PERPH_SUBTYPE (at 0x1805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR1_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR1_BYTE1 (at 0x1820)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018200
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18200
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR1_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR1_BYTE2 (at 0x1821)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018210
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18210
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR1_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR1_BYTE3 (at 0x1822)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018220
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18220
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR2_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR2_BYTE1 (at 0x1823)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018230
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18230
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR2_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR2_BYTE2 (at 0x1824)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018240
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18240
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR2_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR2_BYTE3 (at 0x1825)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018250
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18250
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR3_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR3_BYTE1 (at 0x1826)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018260
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18260
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR3_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR3_BYTE2 (at 0x1827)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018270
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18270
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR3_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR3_BYTE3 (at 0x1828)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018280
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18280
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR4_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR4_BYTE1 (at 0x1829)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018290
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18290
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR4_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR4_BYTE2 (at 0x182a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80182a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x182a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR4_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR4_BYTE3 (at 0x182b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80182b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x182b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR5_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR5_BYTE1 (at 0x182c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80182c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x182c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR5_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR5_BYTE2 (at 0x182d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80182d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x182d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR5_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR5_BYTE3 (at 0x182e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80182e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x182e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR6_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR6_BYTE1 (at 0x182f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80182f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x182f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR6_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR6_BYTE2 (at 0x1830)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018300
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18300
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR6_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_CHGR_HDR6_BYTE3 (at 0x1831)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018310
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18310
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_OTG_HDR1_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_OTG_HDR1_BYTE1 (at 0x1832)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018320
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18320
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_OTG_HDR1_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_OTG_HDR1_BYTE2 (at 0x1833)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018330
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18330
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_OTG_HDR1_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_OTG_HDR1_BYTE3 (at 0x1834)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018340
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18340
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_OTG_HDR2_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_OTG_HDR2_BYTE1 (at 0x1835)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018350
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18350
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_OTG_HDR2_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_OTG_HDR2_BYTE2 (at 0x1836)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018360
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18360
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_OTG_HDR2_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_OTG_HDR2_BYTE3 (at 0x1837)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018370
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18370
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR1_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR1_BYTE1 (at 0x1838)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018380
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18380
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR1_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR1_BYTE2 (at 0x1839)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018390
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18390
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR1_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR1_BYTE3 (at 0x183a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80183a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x183a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR2_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR2_BYTE1 (at 0x183b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80183b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x183b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR2_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR2_BYTE2 (at 0x183c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80183c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x183c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR2_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR2_BYTE3 (at 0x183d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80183d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x183d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR3_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR3_BYTE1 (at 0x183e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80183e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x183e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR3_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR3_BYTE2 (at 0x183f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80183f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x183f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR3_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR3_BYTE3 (at 0x1840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR4_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR4_BYTE1 (at 0x1841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR4_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR4_BYTE2 (at 0x1842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR4_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_BATIF_HDR4_BYTE3 (at 0x1843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR1_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR1_BYTE1 (at 0x1844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR1_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR1_BYTE2 (at 0x1845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR1_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR1_BYTE3 (at 0x1846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR2_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR2_BYTE1 (at 0x1847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR2_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR2_BYTE2 (at 0x1848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR2_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR2_BYTE3 (at 0x1849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR3_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR3_BYTE1 (at 0x184a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR3_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR3_BYTE2 (at 0x184b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR3_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR3_BYTE3 (at 0x184c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR4_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR4_BYTE1 (at 0x184d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR4_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR4_BYTE2 (at 0x184e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR4_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR4_BYTE3 (at 0x184f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR5_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR5_BYTE1 (at 0x1850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR5_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR5_BYTE2 (at 0x1851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_USB_HDR5_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_USB_HDR5_BYTE3 (at 0x1852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR1_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR1_BYTE1 (at 0x1853)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR1_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR1_BYTE2 (at 0x1854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR1_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR1_BYTE3 (at 0x1855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR2_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR2_BYTE1 (at 0x1856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR2_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR2_BYTE2 (at 0x1857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR2_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR2_BYTE3 (at 0x1858)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR3_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR3_BYTE1 (at 0x1859)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR3_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR3_BYTE2 (at 0x185a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80185a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x185a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR3_BYTE3"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR3_BYTE3 (at 0x185b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80185b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x185b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR4_BYTE1"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR4_BYTE1 (at 0x185c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80185c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x185c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "SCHG8998_OTP_HDR_FTRIM_DC_HDR4_BYTE2"
      sgroup "SCHG8998_OTP_HDR_FTRIM_DC_HDR4_BYTE2 (at 0x185d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80185d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x185d0
      line.byte 0x0 "VALUE"
      textline "BITS"
