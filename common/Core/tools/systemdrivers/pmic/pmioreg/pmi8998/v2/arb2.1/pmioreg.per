entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BOB_CONFIG"
  tree "BOB_CONFIG"
    tree "BOB_CONFIG_REVISION1"
      sgroup "BOB_CONFIG_REVISION1 (at 0x1a000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BOB_CONFIG_REVISION2"
      sgroup "BOB_CONFIG_REVISION2 (at 0x1a001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BOB_CONFIG_REVISION3"
      sgroup "BOB_CONFIG_REVISION3 (at 0x1a002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BOB_CONFIG_REVISION4"
      sgroup "BOB_CONFIG_REVISION4 (at 0x1a003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BOB_CONFIG_PERPH_TYPE"
      sgroup "BOB_CONFIG_PERPH_TYPE (at 0x1a004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PERPH_TYPE                               = "
    tree.end
    tree "BOB_CONFIG_PERPH_SUBTYPE"
      sgroup "BOB_CONFIG_PERPH_SUBTYPE (at 0x1a005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PERPH_SUBTYPE                            = "
    tree.end
    tree "BOB_CONFIG_STATUS1"
      sgroup "BOB_CONFIG_STATUS1 (at 0x1a008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (VREG_ERR_FALSE),1 (VREG_ERR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_FAULT                               = " "0 (NO_FAULT),1 (FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PASS_MODE_ACTIVE                         = " "0 (PASS_MODE_ACTIVE_FALSE),1 (PASS_MODE_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP                                      = " "0 (OVP_FALSE),1 (OVP_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTSD                                     = " "0 (OTSD_FALSE),1 (OTSD_TRUE)"
    tree.end
    tree "BOB_CONFIG_STATUS2"
      sgroup "BOB_CONFIG_STATUS2 (at 0x1a009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_PFM                                  = " "0 (PWM),1 (PFM)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   THERMAL_OVERLOAD                         = " "0 (THERMAL_OVERLOAD_FALSE),1 (THERMAL_OVERLOAD_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BCK                                      = " "0 (BCK_FALSE),1 (BCK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BST                                      = " "0 (BST_FALSE),1 (BST_TRUE)"
    tree.end
    tree "BOB_CONFIG_STATUS3"
      sgroup "BOB_CONFIG_STATUS3 (at 0x1a00a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a00a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa00a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COMPARATOR_STATE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VOUT_AUTO_DERATE                         = " "0 (VOUT_AUTO_DERATE_FALSE),1 (VOUT_AUTO_DERATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BOB_CURRENT_HIGH                         = " "0 (BOB_CURRENT_HIGH_FALSE),1 (BOB_CURRENT_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BOB_CURRENT_TOO_HIGH1                    = " "0 (BOB_CURRENT_TOO_HIGH1_FALSE),1 (BOB_CURRENT_TOO_HIGH1_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BOB_CURRENT_TOO_HIGH2                    = " "0 (BOB_CURRENT_TOO_HIGH2_FALSE),1 (BOB_CURRENT_TOO_HIGH2_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_HIGH_HIT_LTCH                = " "0 (BOB_CURRENT_HIGH_HIT_LTCH_FALSE),1 (BOB_CURRENT_TOO_HIGH_HIT_LTCH_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_HIT_LTCH           = " "0 (BOB_CURRENT_TOO_HIGH1_HIT_LTCH_FALSE),1 (BOB_CURRENT_TOO_HIGH1_HIT_LTCH_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_TOO_HIGH2_HIT_LTCH           = " "0 (BOB_CURRENT_TOO_HIGH2_HIT_LTCH_FALSE),1 (BOB_CURRENT_TOO_HIGH2_HIT_LTCH_TRUE)"
    tree.end
    tree "BOB_CONFIG_STATUS4"
      sgroup "BOB_CONFIG_STATUS4 (at 0x1a00b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a00b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa00b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_TARGET                              = "
    tree.end
    tree "BOB_CONFIG_STATUS5"
      sgroup "BOB_CONFIG_STATUS5 (at 0x1a00c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a00c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa00c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LMH_LEVEL2                               = " "0 (LMH_LEVEL2_FALSE),1 (LMH_LEVEL2_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LMH_LEVEL1                               = " "0 (LMH_LEVEL1_FALSE),1 (LMH_LEVEL1_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LMH_LEVEL0                               = " "0 (LMH_LEVEL0_FALSE),1 (LMH_LEVEL0_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLASH_ON_STATE                           = " "0 (FLASH_ON_STATE_FALSE),1 (FLASH_ON_STATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EXT_CTRL2_STATE                          = " "0 (EXT_CTRL2_STATE_FALSE),1 (EXT_CTRL2_STATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EXT_CTRL1_STATE                          = " "0 (EXT_CTRL1_STATE_FALSE),1 (EXT_CTRL1_STATE_TRUE)"
    tree.end
    tree "BOB_CONFIG_INT_RT_STS"
      sgroup "BOB_CONFIG_INT_RT_STS (at 0x1a010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (VREG_FAULT_FALSE),1 (VREG_FAULT_TRUE)"
    tree.end
    tree "BOB_CONFIG_INT_SET_TYPE"
      sgroup "BOB_CONFIG_INT_SET_TYPE (at 0x1a011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_SET_TYPE                      = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_SET_TYPE                      = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "BOB_CONFIG_INT_POLARITY_HIGH"
      sgroup "BOB_CONFIG_INT_POLARITY_HIGH (at 0x1a012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_POLARITY_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_POLARITY_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BOB_CONFIG_INT_POLARITY_LOW"
      sgroup "BOB_CONFIG_INT_POLARITY_LOW (at 0x1a013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_POLARITY_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_POLARITY_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BOB_CONFIG_INT_LATCHED_CLR"
      sgroup "BOB_CONFIG_INT_LATCHED_CLR (at 0x1a014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "BOB_CONFIG_INT_EN_SET"
      sgroup "BOB_CONFIG_INT_EN_SET (at 0x1a015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BOB_CONFIG_INT_EN_CLR"
      sgroup "BOB_CONFIG_INT_EN_CLR (at 0x1a016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_CLR                           = " "0, 1"
    tree.end
    tree "BOB_CONFIG_INT_LATCHED_STS"
      sgroup "BOB_CONFIG_INT_LATCHED_STS (at 0x1a018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "BOB_CONFIG_INT_PENDING_STS"
      sgroup "BOB_CONFIG_INT_PENDING_STS (at 0x1a019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "BOB_CONFIG_INT_MID_SEL"
      sgroup "BOB_CONFIG_INT_MID_SEL (at 0x1a01a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "BOB_CONFIG_INT_PRIORITY"
      sgroup "BOB_CONFIG_INT_PRIORITY (at 0x1a01b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "BOB_CONFIG_VREG_FORCE_EN"
      sgroup "BOB_CONFIG_VREG_FORCE_EN (at 0x1a030)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0300
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0300
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_FORCE_EN                            = " "0 (VREG_FORCE_EN_FALSE),1 (VREG_FORCE_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_EXT_CTRL1_FORCE_EN"
      sgroup "BOB_CONFIG_EXT_CTRL1_FORCE_EN (at 0x1a031)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0310
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0310
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EXT_CTRL1_FORCE_EN                       = " "0 (EXT_CTRL1_FORCE_EN_FALSE),1 (EXT_CTRL1_FORCE_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_EXT_CTRL2_FORCE_EN"
      sgroup "BOB_CONFIG_EXT_CTRL2_FORCE_EN (at 0x1a032)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0320
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0320
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EXT_CTRL2_FORCE_EN                       = " "0 (EXT_CTRL2_FORCE_EN_FALSE),1 (EXT_CTRL2_FORCE_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_FLASH_ON_FORCE_EN"
      sgroup "BOB_CONFIG_FLASH_ON_FORCE_EN (at 0x1a033)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0330
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0330
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FLASH_ON_FORCE_EN                        = " "0 (FLASH_ON_FORCE_EN_FALSE),1 (FLASH_ON_FORCE_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_FLASH_OVHD_CTL"
      sgroup "BOB_CONFIG_FLASH_OVHD_CTL (at 0x1a034)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0340
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0340
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FOLLOW_OVHD_HW                     = " "0 (FLASH_FOLLOW_OVHD_HW_FALSE),1 (FLASH_FOLLOW_OVHD_HW_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLASH_FOLLOW_ON_HW                       = " "0 (FLASH_FOLLOW_ON_HW_FALSE),1 (FLASH_FOLLOW_ON_HW_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EXT_CTRL1_FOLLOW_FLASH_ON                = " "0 (EXT_CTRL1_FOLLOW_FLASH_ON_FALSE),1 (EXT_CTRL1_FOLLOW_FLASH_ON_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EXT_CTRL2_FOLLOW_FLASH_ON                = " "0 (EXT_CTRL2_FOLLOW_FLASH_ON_FALSE),1 (EXT_CTRL2_FOLLOW_FLASH_ON_TRUE)"
    tree.end
    tree "BOB_CONFIG_EXT_CTRL_FOLLOW"
      sgroup "BOB_CONFIG_EXT_CTRL_FOLLOW (at 0x1a036)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0360
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0360
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EXT_CTRL2_FOLLOW                         = " "0 (EXT_CTRL2_FOLLOW_FALSE),1 (EXT_CTRL2_FOLLOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EXT_CTRL1_FOLLOW                         = " "0 (EXT_CTRL1_FOLLOW_FALSE),1 (EXT_CTRL1_FOLLOW_TRUE)"
    tree.end
    tree "BOB_CONFIG_VOUT_LB"
      sgroup "BOB_CONFIG_VOUT_LB (at 0x1a040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_LB                                  = "
    tree.end
    tree "BOB_CONFIG_VOUT_UB"
      sgroup "BOB_CONFIG_VOUT_UB (at 0x1a041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VOUT_UB                                  = "
    tree.end
    tree "BOB_CONFIG_VSET_VALID_LB"
      sgroup "BOB_CONFIG_VSET_VALID_LB (at 0x1a042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID_LB                            = "
    tree.end
    tree "BOB_CONFIG_VSET_VALID_UB"
      sgroup "BOB_CONFIG_VSET_VALID_UB (at 0x1a043)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "BOB_CONFIG_VOUT_MODE_CTRL"
      sgroup "BOB_CONFIG_VOUT_MODE_CTRL (at 0x1a045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VOUT_MODE_CTRL                           = " "0 (PASS),1 (FPFM),2 (AUTO),3 (FPWM)"
    tree.end
    tree "BOB_CONFIG_VREG_EN"
      sgroup "BOB_CONFIG_VREG_EN (at 0x1a046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_EN                                  = " "0 (VREG_EN_FALSE),1 (VREG_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_PD_CTL"
      sgroup "BOB_CONFIG_PD_CTL (at 0x1a048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUTDC_EN                              = " "0 (OUTPUTDC_EN_FALSE),1 (OUTPUTDC_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_VOUT_EXT_CTRL1_LB"
      sgroup "BOB_CONFIG_VOUT_EXT_CTRL1_LB (at 0x1a04a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_EXT_CTRL1_LB                        = "
    tree.end
    tree "BOB_CONFIG_VOUT_EXT_CTRL1_UB"
      sgroup "BOB_CONFIG_VOUT_EXT_CTRL1_UB (at 0x1a04b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VOUT_EXT_CTRL1_UB                        = "
    tree.end
    tree "BOB_CONFIG_VOUT_EXT_CTRL2_LB"
      sgroup "BOB_CONFIG_VOUT_EXT_CTRL2_LB (at 0x1a04c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_EXT_CTRL2_LB                        = "
    tree.end
    tree "BOB_CONFIG_VOUT_EXT_CTRL2_UB"
      sgroup "BOB_CONFIG_VOUT_EXT_CTRL2_UB (at 0x1a04d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VOUT_EXT_CTRL2_UB                        = "
    tree.end
    tree "BOB_CONFIG_VOUT_FLASH_INIT_LB"
      sgroup "BOB_CONFIG_VOUT_FLASH_INIT_LB (at 0x1a04e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_FLASH_INIT_LB                       = "
    tree.end
    tree "BOB_CONFIG_VOUT_FLASH_INIT_UB"
      sgroup "BOB_CONFIG_VOUT_FLASH_INIT_UB (at 0x1a04f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VOUT_FLASH_INIT_UB                       = "
    tree.end
    tree "BOB_CONFIG_FLASH_MODE_CTRL"
      sgroup "BOB_CONFIG_FLASH_MODE_CTRL (at 0x1a050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FLASH_MODE_CTRL                          = " "0 (PASS),1 (FPFM),2 (AUTO),3 (FPWM)"
    tree.end
    tree "BOB_CONFIG_EXT_CTRL1_MODE_CTRL"
      sgroup "BOB_CONFIG_EXT_CTRL1_MODE_CTRL (at 0x1a051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXT_CTRL1_MODE                           = " "0 (PASS),1 (FPFM),2 (AUTO),3 (FPWM)"
    tree.end
    tree "BOB_CONFIG_EXT_CTRL2_MODE_CTRL"
      sgroup "BOB_CONFIG_EXT_CTRL2_MODE_CTRL (at 0x1a052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EXT_CTRL2_MODE                           = " "0 (PASS),1 (FPFM),2 (AUTO),3 (FPWM)"
    tree.end
    tree "BOB_CONFIG_VOUT_AUTO_DERATE_EN"
      sgroup "BOB_CONFIG_VOUT_AUTO_DERATE_EN (at 0x1a058)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VOUT_AUTO_DERATE_EN                      = " "0 (VOUT_AUTO_DERATE_EN_FALSE),1 (VOUT_AUTO_DERATE_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_VOTE_PRIORITY"
      sgroup "BOB_CONFIG_VOTE_PRIORITY (at 0x1a059)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VOUT_FLASH_INIT_PRIORITY                 = " "0 (VOUT_FLASH_INIT_PRIORITY_LOW),1 (VOUT_FLASH_INIT_PRIORITY_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VOUT_EXT_CTRL2_PRIORITY                  = " "0 (VOUT_EXT_CTRL2_PRIORITY_LOW),1 (VOUT_EXT_CTRL2_PRIORITY_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VOUT_EXT_CTRL1_PRIORITY                  = " "0 (VOUT_EXT_CTRL1_PRIORITY_LOW),1 (VOUT_EXT_CTRL1_PRIORITY_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VOUT_PRIORITY                            = " "0 (VOUT_PRIORITY_LOW),1 (VOUT_PRIORITY_HIGH)"
    tree.end
    tree "BOB_CONFIG_ZCX_OFFSET_SEL"
      sgroup "BOB_CONFIG_ZCX_OFFSET_SEL (at 0x1a05a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a05a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa05a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZCX_OFFSET_SEL                           = " "0, 1"
    tree.end
    tree "BOB_CONFIG_CFG_TEMP_SEL"
      sgroup "BOB_CONFIG_CFG_TEMP_SEL (at 0x1a05b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a05b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa05b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_TEMP_SEL                             = " "0 (CFG_TEMP_SEL_100C),1 (CFG_TEMP_SEL_110C),2 (CFG_TEMP_SEL_120C),3 (CFG_TEMP_SEL_130C)"
    tree.end
    tree "BOB_CONFIG_STEPPER_SS_CTL"
      sgroup "BOB_CONFIG_STEPPER_SS_CTL (at 0x1a060)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_STEPPER_EN                            = " "0 (SS_STEPPER_EN_FALSE),1 (SS_STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DVS_STEP_DLY                          = " "0 (SS_DVS_STEP_DLY_1CLK),1 (SS_DVS_STEP_DLY_2CLK),2 (SS_DVS_STEP_DLY_3CLK),3 (SS_DVS_STEP_DLY_4CLK),4 (SS_DVS_STEP_DLY_6CLK),5 (SS_DVS_STEP_DLY_8CLK),6 (SS_DVS_STEP_DLY_16CLK),7 (SS_DVS_STEP_DLY_32CLK)"
    tree.end
    tree "BOB_CONFIG_STEPPER_VOUT_CTL"
      sgroup "BOB_CONFIG_STEPPER_VOUT_CTL (at 0x1a061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VOUT_DVS_STEPPER_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOUT_DVS_STEP_DLY                        = " "0 (VOUT_DVS_STEP_DLY_1CLK),1 (VOUT_DVS_STEP_DLY_2CLK),2 (VOUT_DVS_STEP_DLY_3CLK),3 (VOUT_DVS_STEP_DLY_4CLK),4 (VOUT_DVS_STEP_DLY_6CLK),5 (VOUT_DVS_STEP_DLY_8CLK),6 (VOUT_DVS_STEP_DLY_16CLK),7 (VOUT_DVS_STEP_DLY_32CLK)"
    tree.end
    tree "BOB_CONFIG_STEPPER_FLASH_CTL"
      sgroup "BOB_CONFIG_STEPPER_FLASH_CTL (at 0x1a062)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FLASH_DVS_STEP_DLY                       = " "0 (FLASH_DVS_STEP_DLY_1CLK),1 (FLASH_DVS_STEP_DLY_2CLK),2 (FLASH_DVS_STEP_DLY_3CLK),3 (FLASH_DVS_STEP_DLY_4CLK),4 (FLASH_DVS_STEP_DLY_6CLK),5 (FLASH_DVS_STEP_DLY_8CLK),6 (FLASH_DVS_STEP_DLY_16CLK),7 (FLASH_DVS_STEP_DLY_32CLK)"
    tree.end
    tree "BOB_CONFIG_VOUT_MIN0"
      sgroup "BOB_CONFIG_VOUT_MIN0 (at 0x1a064)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_MIN0                                = "
    tree.end
    tree "BOB_CONFIG_VOUT_MIN1"
      sgroup "BOB_CONFIG_VOUT_MIN1 (at 0x1a065)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_MIN1                                = "
    tree.end
    tree "BOB_CONFIG_FAULT_CLR"
      sgroup "BOB_CONFIG_FAULT_CLR (at 0x1a066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FAULT_GLOBAL_BC                          = " "0 (OCP_GLOBAL_BROADCAST_EN_FALSE),1 (OCP_GLOBAL_BROADCAST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FAULT_CLR                                = " "0 (FAULT_CLR_FALSE),1 (FAULT_CLR_TRUE)"
    tree.end
    tree "BOB_CONFIG_FAULT_CFG"
      sgroup "BOB_CONFIG_FAULT_CFG (at 0x1a067)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   FAULT_CFG                                = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAULT_INT_CFG                            = "
    tree.end
    tree "BOB_CONFIG_ULS_VSET_LSB"
      sgroup "BOB_CONFIG_ULS_VSET_LSB (at 0x1a068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   VOUT_MAX_2_0                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BOB_CONFIG_ULS_VSET_MSB"
      sgroup "BOB_CONFIG_ULS_VSET_MSB (at 0x1a069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VOUT_MAX_7_3                             = "
    tree.end
    tree "BOB_CONFIG_LLS_VSET_LSB"
      sgroup "BOB_CONFIG_LLS_VSET_LSB (at 0x1a06a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a06a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa06a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   VOUT_MIN_2_0                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BOB_CONFIG_LLS_VSET_MSB"
      sgroup "BOB_CONFIG_LLS_VSET_MSB (at 0x1a06b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a06b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa06b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VOUT_MIN_7_3                             = "
    tree.end
    tree "BOB_CONFIG_PSTG_SEL_BCK"
      sgroup "BOB_CONFIG_PSTG_SEL_BCK (at 0x1a06c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a06c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa06c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   PSTG_SLEW_CTRL_BST                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PSTG_SLEW_CTRL_BCK                       = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_PSTG_SEL_BCK2"
      sgroup "BOB_CONFIG_PSTG_SEL_BCK2 (at 0x1a06d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a06d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa06d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BCK_ON2OFF_EXTENDED_DEADTIME             = " "0, 1"
    tree.end
    tree "BOB_CONFIG_STATUS_DEB_CTL"
      sgroup "BOB_CONFIG_STATUS_DEB_CTL (at 0x1a070)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (VREG_READY_DEB_1LFRC),1 (VREG_READY_DEB_2LFRC),2 (VREG_READY_DEB_4LFRC),3 (VREG_READY_DEB_INFINITY)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (VREG_ERROR_DEB_1LFRC),1 (VREG_ERROR_DEB_2LFRC),2 (VREG_ERROR_DEB_4LFRC),3 (VREG_ERROR_DEB_INFINITY)"
    tree.end
    tree "BOB_CONFIG_CAL_STATUS"
      sgroup "BOB_CONFIG_CAL_STATUS (at 0x1a071)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VEA1_GM_TRIM_CAL_FAULT                   = " "0 (VEA1_GM_CAL_FAULT_FALSE),1 (VEA1_GM_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ISNS_TRIM_BCK_CAL_FAULT                  = " "0 (ISNS_BCK_CAL_FAULT_FALSE),1 (ISNS_BCK_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ISNS_TRIM_BST_CAL_FAULT                  = " "0 (ISNS_BST_CAL_FAULT_FALSE),1 (ISNS_BST_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ZCX_TRIM_CAL_FAULT                       = " "0 (ZCX_CAL_FAULT_FALSE),1 (ZCX_CAL_FAULT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "BOB_CONFIG_VEA1_GM_TRIM_CAL_VALUE"
      sgroup "BOB_CONFIG_VEA1_GM_TRIM_CAL_VALUE (at 0x1a072)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VEA1_GM_TRIM                             = "
    tree.end
    tree "BOB_CONFIG_ISNS_TRIM_BCK_CAL_VALUE"
      sgroup "BOB_CONFIG_ISNS_TRIM_BCK_CAL_VALUE (at 0x1a073)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ISNS_TRIM_BCK                            = "
    tree.end
    tree "BOB_CONFIG_ISNS_TRIM_BST_CAL_VALUE"
      sgroup "BOB_CONFIG_ISNS_TRIM_BST_CAL_VALUE (at 0x1a074)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ISNS_TRIM_BST                            = "
    tree.end
    tree "BOB_CONFIG_ZCX_TRIM_CAL_VALUE"
      sgroup "BOB_CONFIG_ZCX_TRIM_CAL_VALUE (at 0x1a075)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ZCX_TRIM                                 = "
    tree.end
    tree "BOB_CONFIG_CAL_TIMER_CTL"
      sgroup "BOB_CONFIG_CAL_TIMER_CTL (at 0x1a076)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER                                = "
    tree.end
    tree "BOB_CONFIG_CAL_CTL"
      sgroup "BOB_CONFIG_CAL_CTL (at 0x1a077)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VEA1_GM_CAL_EN                           = " "0 (TRIM_REG_CODE),1 (AUTOCAL_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ISNS_BCK_CAL_EN                          = " "0 (TRIM_REG_CODE),1 (AUTOCAL_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ISNS_BST_CAL_EN                          = " "0 (TRIM_REG_CODE),1 (AUTOCAL_ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ZCX_CAL_EN                               = " "0 (TRIM_REG_CODE),1 (AUTOCAL_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_CAL_ENG_EN                          = " "0 (TRIM_CAL_ENG_EN_FALSE),1 (TRIM_CAL_ENG_EN_TRUE)"
    tree.end
    tree "BOB_CONFIG_CAL_REQUEST"
      sgroup "BOB_CONFIG_CAL_REQUEST (at 0x1a078)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
    tree.end
    tree "BOB_CONFIG_PD_CTL_FORCE_EN"
      sgroup "BOB_CONFIG_PD_CTL_FORCE_EN (at 0x1a083)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUTDC_FORCE_EN                        = " "0, 1"
    tree.end
    tree "BOB_CONFIG_PFM_CONFIG"
      sgroup "BOB_CONFIG_PFM_CONFIG (at 0x1a08e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a08e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa08e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PASS_CONFIG_IPK_SEL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SS_ILIM                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_CONFIG_IPK                           = " "0 (PFM_CONFIG_IPK_0A5),1 (PFM_CONFIG_IPK_0A75),2 (PFM_CONFIG_IPK_1A0),3 (PFM_CONFIG_IPK_1A25)"
    tree.end
    tree "BOB_CONFIG_PFM_CONFIG2"
      sgroup "BOB_CONFIG_PFM_CONFIG2 (at 0x1a08f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a08f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa08f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_VEA_DLY                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_ENTER_VLOW_BLK_DISABLE               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_EXIT_S1_DISABLE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_TO_PFM_BLANKING                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_TO_PFM_TH                            = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_TON_CONFIG"
      sgroup "BOB_CONFIG_TON_CONFIG (at 0x1a090)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   FPFM_ONTIME_SEL                          = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BST_MAX_TON                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_MAX_TON                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BST_MIN_TON                              = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_BLANK_CONFIG"
      sgroup "BOB_CONFIG_BLANK_CONFIG (at 0x1a091)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   PFM_ENTER_BLANK                          = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   S1_BLANK_SEL                             = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_MODULATOR_CONFIG"
      sgroup "BOB_CONFIG_MODULATOR_CONFIG (at 0x1a092)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VOUT_SC_TH_SEL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_DCM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSW_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PSTG_ANTIRING                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CTRL                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CTRL                                 = " "0, 1"
    tree.end
    tree "BOB_CONFIG_ASM_MODE_CTRL"
      sgroup "BOB_CONFIG_ASM_MODE_CTRL (at 0x1a0a0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ASM_MODE_CTRL                            = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_ASM_MODE_OVERRIDE_EN"
      sgroup "BOB_CONFIG_ASM_MODE_OVERRIDE_EN (at 0x1a0a1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ASM_MODE_OVERRIDE_EN                     = " "0, 1"
    tree.end
    tree "BOB_CONFIG_COMP_CONFIG1"
      sgroup "BOB_CONFIG_COMP_CONFIG1 (at 0x1a0b8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VEA2_RI_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VEA2_CP_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VEA1_GM_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_COMP_CONFIG2"
      sgroup "BOB_CONFIG_COMP_CONFIG2 (at 0x1a0b9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   VEA1_CZ_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VEA1_CP_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_COMP_CONFIG3"
      sgroup "BOB_CONFIG_COMP_CONFIG3 (at 0x1a0ba)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VEA1_RZ_SEL                              = "
    tree.end
    tree "BOB_CONFIG_GEN_LVL"
      sgroup "BOB_CONFIG_GEN_LVL (at 0x1a0bc)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0bc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0bc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GEN_LVL                                  = "
    tree.end
    tree "BOB_CONFIG_SEC_ACCESS"
      sgroup "BOB_CONFIG_SEC_ACCESS (at 0x1a0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BOB_CONFIG_PERPH_RESET_CTL1"
      sgroup "BOB_CONFIG_PERPH_RESET_CTL1 (at 0x1a0d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "BOB_CONFIG_PERPH_RESET_CTL2"
      sgroup "BOB_CONFIG_PERPH_RESET_CTL2 (at 0x1a0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "BOB_CONFIG_PERPH_RESET_CTL3"
      sgroup "BOB_CONFIG_PERPH_RESET_CTL3 (at 0x1a0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "BOB_CONFIG_PERPH_RESET_CTL4"
      sgroup "BOB_CONFIG_PERPH_RESET_CTL4 (at 0x1a0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "BOB_CONFIG_INT_TEST1"
      sgroup "BOB_CONFIG_INT_TEST1 (at 0x1a0e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BOB_CONFIG_INT_TEST_VAL"
      sgroup "BOB_CONFIG_INT_TEST_VAL (at 0x1a0e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FAULT_TEST_VAL                           = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "BOB_CONFIG_ATEST_LV"
      sgroup "BOB_CONFIG_ATEST_LV (at 0x1a0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_LV                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BOB_CONFIG_ATEST_MV"
      sgroup "BOB_CONFIG_ATEST_MV (at 0x1a0e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_MV                                 = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_DTEST_SEL_ASM"
      sgroup "BOB_CONFIG_DTEST_SEL_ASM (at 0x1a0e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL_ASM                            = "
    tree.end
    tree "BOB_CONFIG_ASM_TEST_MODE_SEL"
      sgroup "BOB_CONFIG_ASM_TEST_MODE_SEL (at 0x1a0e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ASM_TEST_MODE_SEL                        = "
    tree.end
    tree "BOB_CONFIG_DTEST_SEL"
      sgroup "BOB_CONFIG_DTEST_SEL (at 0x1a0e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "BOB_CONFIG_TEST_MODE_CONTROL"
      sgroup "BOB_CONFIG_TEST_MODE_CONTROL (at 0x1a0e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VTEMP_ATEST3_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VRS_TEST_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAMPOS_TSTEN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RAMP_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RAMP_ATEST_EN                            = " "0, 1"
    tree.end
    tree "BOB_CONFIG_TEST_MODE_COMPARATOR_OVERRIDE_EN"
      sgroup "BOB_CONFIG_TEST_MODE_COMPARATOR_OVERRIDE_EN (at 0x1a0ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ILIM_PWM_SMPL_OVERRIDE_EN                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ILIM_S1_OVERRIDE_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIM_S2_OVERRIDE_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VOUT_SC_OVERRIDE_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYP_OUT_OVERRIDE_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VOUT_OVP_OVERRIDE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTSD_OVERRIDE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OVT_OVERRIDE_EN                          = " "0, 1"
    tree.end
    tree "BOB_CONFIG_TEST_MODE_COMPARATOR_OVERRIDE"
      sgroup "BOB_CONFIG_TEST_MODE_COMPARATOR_OVERRIDE (at 0x1a0eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ILIM_PWM_SMPL_OVERRIDE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ILIM_S1_OVERRIDE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIM_S2_OVERRIDE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VOUT_SC_OVERRIDE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BYP_OUT_OVERRIDE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VOUT_OVP_OVERRIDE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTSD_OVERRIDE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OVT_OVERRIDE                             = " "0, 1"
    tree.end
    tree "BOB_CONFIG_BOB_TESTMODE_EN"
      sgroup "BOB_CONFIG_BOB_TESTMODE_EN (at 0x1a0ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_TESTMODE_EN                          = " "0, 1"
    tree.end
    tree "BOB_CONFIG_TEST_MODE_BLOCK_EN1"
      sgroup "BOB_CONFIG_TEST_MODE_BLOCK_EN1 (at 0x1a0ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_OVERRIDE1                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_BOB_STG0_OVERRRIDE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_BOB_STG1_OVERRRIDE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_BOB_STG2_OVERRRIDE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_VSNSPFM_OVERRRIDE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_PWM_COMP_OVERRRIDE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_BYPOUT_COMP_OVERRRIDE                 = " "0, 1"
    tree.end
    tree "BOB_CONFIG_TEST_MODE_BLOCK_EN2"
      sgroup "BOB_CONFIG_TEST_MODE_BLOCK_EN2 (at 0x1a0ee)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_OVERRIDE2                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_SW_OVERRRIDE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_TEMPSNS_OVERRRIDE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_SOFTILIM_OVERRRIDE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_VOUTDSCHG_OVERRRIDE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_ISNSLOW_OVERRRIDE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_VEA_OVERRRIDE                      = " "0, 1"
    tree.end
    tree "BOB_CONFIG_TEST_DIG_CTRL"
      sgroup "BOB_CONFIG_TEST_DIG_CTRL (at 0x1a0ef)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_CG_TRANSPARENT                     = " "0, 1"
    tree.end
    tree "BOB_CONFIG_TRIM_NUM"
      sgroup "BOB_CONFIG_TRIM_NUM (at 0x1a0f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_NUM                                 = "
    tree.end
    tree "BOB_CONFIG_ANA_BLANK_TRIM"
      sgroup "BOB_CONFIG_ANA_BLANK_TRIM (at 0x1a0f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ANA_BLANK_TRIM                           = "
    tree.end
    tree "BOB_CONFIG_VEA1_GM_TRIM"
      sgroup "BOB_CONFIG_VEA1_GM_TRIM (at 0x1a0f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VEA1_GM_TRIM                             = "
    tree.end
    tree "BOB_CONFIG_ISNS_TRIM_BCK"
      sgroup "BOB_CONFIG_ISNS_TRIM_BCK (at 0x1a0f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ISNS_TRIM_BCK                            = "
    tree.end
    tree "BOB_CONFIG_ISNS_TRIM_BST"
      sgroup "BOB_CONFIG_ISNS_TRIM_BST (at 0x1a0f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ISNS_TRIM_BST                            = "
    tree.end
    tree "BOB_CONFIG_ZCX_TRIM"
      sgroup "BOB_CONFIG_ZCX_TRIM (at 0x1a0f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ZCX_TRIM                                 = "
    tree.end
    tree "BOB_CONFIG_SEL_VREF_TRIM"
      sgroup "BOB_CONFIG_SEL_VREF_TRIM (at 0x1a0f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SEL_VREF_TRIM                            = "
    tree.end
    tree "BOB_CONFIG_RAMP_TRIM"
      sgroup "BOB_CONFIG_RAMP_TRIM (at 0x1a0f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
    tree "BOB_CONFIG_RAMPOS_TRIM"
      sgroup "BOB_CONFIG_RAMPOS_TRIM (at 0x1a0f8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMPOS_TRIM                              = "
    tree.end
    tree "BOB_CONFIG_ISNS_TRIM_IOS"
      sgroup "BOB_CONFIG_ISNS_TRIM_IOS (at 0x1a0f9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISNS_IOS_TRIM                            = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BOB_CONFIG_SEL_REF_RAMP_TRIM"
      sgroup "BOB_CONFIG_SEL_REF_RAMP_TRIM (at 0x1a0fa)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_REF_RAMP_TRIM                        = "
    tree.end
    tree "BOB_CONFIG_VREG_OK_OFFSET_TRIM"
      sgroup "BOB_CONFIG_VREG_OK_OFFSET_TRIM (at 0x1a0fb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_OFFSET_TRIM                      = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_VLOW_OFFSET_TRIM"
      sgroup "BOB_CONFIG_VLOW_OFFSET_TRIM (at 0x1a0fc)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VLOW_OFFSET_TRIM                         = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_VHIGH_OFFSET_TRIM"
      sgroup "BOB_CONFIG_VHIGH_OFFSET_TRIM (at 0x1a0fd)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VHIGH_OFFSET_TRIM                        = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_VEXIT_OFFSET_TRIM"
      sgroup "BOB_CONFIG_VEXIT_OFFSET_TRIM (at 0x1a0fe)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VEXIT_OFFSET_TRIM                        = " "0, 1, 2, 3"
    tree.end
    tree "BOB_CONFIG_ISNS_GAIN_TRIM"
      sgroup "BOB_CONFIG_ISNS_GAIN_TRIM (at 0x1a0ff)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILIMPK_MAXTH_DERATE_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ISNS_BST_GAIN_TRIM                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ISNS_BCK_GAIN_TRIM                       = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "BOB_MONITORING"
  tree "BOB_MONITORING"
    tree "BOB_MONITORING_REVISION1"
      sgroup "BOB_MONITORING_REVISION1 (at 0x1a100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BOB_MONITORING_REVISION2"
      sgroup "BOB_MONITORING_REVISION2 (at 0x1a101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BOB_MONITORING_REVISION3"
      sgroup "BOB_MONITORING_REVISION3 (at 0x1a102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BOB_MONITORING_REVISION4"
      sgroup "BOB_MONITORING_REVISION4 (at 0x1a103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BOB_MONITORING_PERPH_TYPE"
      sgroup "BOB_MONITORING_PERPH_TYPE (at 0x1a104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PERPH_TYPE                               = "
    tree.end
    tree "BOB_MONITORING_PERPH_SUBTYPE"
      sgroup "BOB_MONITORING_PERPH_SUBTYPE (at 0x1a105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PERPH_SUBTYPE                            = "
    tree.end
    tree "BOB_MONITORING_STATUS1"
      sgroup "BOB_MONITORING_STATUS1 (at 0x1a108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (VREG_ERR_FALSE),1 (VREG_ERR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_FAULT                               = " "0 (NO_FAULT),1 (FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VREG_OK                                  = " "0 (VREG_OK_FALSE),1 (VREG_OK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PASS_MODE_ACTIVE                         = " "0 (PASS_MODE_ACTIVE_FALSE),1 (PASS_MODE_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OVP                                      = " "0 (OVP_FALSE),1 (OVP_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTSD                                     = " "0 (OTSD_FALSE),1 (OTSD_TRUE)"
    tree.end
    tree "BOB_MONITORING_STATUS2"
      sgroup "BOB_MONITORING_STATUS2 (at 0x1a109)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_PFM                                  = " "0 (PWM),1 (PFM)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VOUT_AUTO_DERATE                         = " "0 (THERMAL_OVERLOAD_FALSE),1 (THERMAL_OVERLOAD_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BCK                                      = " "0 (BCK_FALSE),1 (BCK_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BST                                      = " "0 (BST_FALSE),1 (BST_TRUE)"
    tree.end
    tree "BOB_MONITORING_STATUS4"
      sgroup "BOB_MONITORING_STATUS4 (at 0x1a10b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a10b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa10b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VOUT_TARGET                              = "
    tree.end
    tree "BOB_MONITORING_STATUS5"
      sgroup "BOB_MONITORING_STATUS5 (at 0x1a10c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a10c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa10c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLASH_ON_STATE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EXT_CTRL2_STATE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EXT_CTRL1_STATE                          = " "0, 1"
    tree.end
    tree "BOB_MONITORING_INT_RT_STS"
      sgroup "BOB_MONITORING_INT_RT_STS (at 0x1a110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_RT_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_RT_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_HIT_RT_STS              = " "0, 1"
    tree.end
    tree "BOB_MONITORING_INT_SET_TYPE"
      sgroup "BOB_MONITORING_INT_SET_TYPE (at 0x1a111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_SET_TYPE                      = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_SET_TYPE                   = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_SET_TYPE                   = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_SET_TYPE                   = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_SET_TYPE           = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_SET_TYPE           = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_SET_TYPE                = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "BOB_MONITORING_INT_POLARITY_HIGH"
      sgroup "BOB_MONITORING_INT_POLARITY_HIGH (at 0x1a112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_POLARITY_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_POLARITY_HIGH              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_POLARITY_HIGH              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_POLARITY_HIGH              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_POLARITY_HIGH      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_POLARITY_HIGH      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_POLARITY_HIGH           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BOB_MONITORING_INT_POLARITY_LOW"
      sgroup "BOB_MONITORING_INT_POLARITY_LOW (at 0x1a113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_POLARITY_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_POLARITY_LOW               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_POLARITY_LOW               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_POLARITY_LOW               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_POLARITY_LOW       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_POLARITY_LOW       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_POLARITY_LOW            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BOB_MONITORING_INT_LATCHED_CLR"
      sgroup "BOB_MONITORING_INT_LATCHED_CLR (at 0x1a114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "BOB_MONITORING_INT_EN_SET"
      sgroup "BOB_MONITORING_INT_EN_SET (at 0x1a115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_EN_SET                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_EN_SET                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_EN_SET                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_EN_SET             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_EN_SET             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BOB_MONITORING_INT_EN_CLR"
      sgroup "BOB_MONITORING_INT_EN_CLR (at 0x1a116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_EN_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_EN_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_EN_CLR                  = " "0, 1"
    tree.end
    tree "BOB_MONITORING_INT_LATCHED_STS"
      sgroup "BOB_MONITORING_INT_LATCHED_STS (at 0x1a118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_LATCHED_STS        = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_LATCHED_STS        = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "BOB_MONITORING_INT_PENDING_STS"
      sgroup "BOB_MONITORING_INT_PENDING_STS (at 0x1a119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_PENDING_STS        = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_PENDING_STS        = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "BOB_MONITORING_INT_MID_SEL"
      sgroup "BOB_MONITORING_INT_MID_SEL (at 0x1a11a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "BOB_MONITORING_INT_PRIORITY"
      sgroup "BOB_MONITORING_INT_PRIORITY (at 0x1a11b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "BOB_MONITORING_LMH_LVL0_SOURCE"
      sgroup "BOB_MONITORING_LMH_LVL0_SOURCE (at 0x1a140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL0_SOURCE                          = "
    tree.end
    tree "BOB_MONITORING_LMH_LVL1_SOURCE"
      sgroup "BOB_MONITORING_LMH_LVL1_SOURCE (at 0x1a141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL1_SOURCE                          = "
    tree.end
    tree "BOB_MONITORING_LMH_LVL2_SOURCE"
      sgroup "BOB_MONITORING_LMH_LVL2_SOURCE (at 0x1a142)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL2_SOURCE                          = "
    tree.end
    tree "BOB_MONITORING_LMH_LVL0_SOURCE_FLASH"
      sgroup "BOB_MONITORING_LMH_LVL0_SOURCE_FLASH (at 0x1a143)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL0_SOURCE_FLASH                    = "
    tree.end
    tree "BOB_MONITORING_LMH_LVL1_SOURCE_FLASH"
      sgroup "BOB_MONITORING_LMH_LVL1_SOURCE_FLASH (at 0x1a144)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL1_SOURCE_FLASH                    = "
    tree.end
    tree "BOB_MONITORING_LMH_LVL2_SOURCE_FLASH"
      sgroup "BOB_MONITORING_LMH_LVL2_SOURCE_FLASH (at 0x1a145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL2_SOURCE_FLASH                    = "
    tree.end
    tree "BOB_MONITORING_ILIM_DENSITY_TH"
      sgroup "BOB_MONITORING_ILIM_DENSITY_TH (at 0x1a146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ILIM_DENSITY_TH                          = " "0 (ILIM_DENSITY_TH_CONSEQUETIVE),1 (ILIM_DENSITY_TH_HALF),2 (ILIM_DENSITY_TH_THIRD),3 (ILIM_DENSITY_TH_QUARTER)"
    tree.end
    tree "BOB_MONITORING_FLASH_INT_BLANK"
      sgroup "BOB_MONITORING_FLASH_INT_BLANK (at 0x1a152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FLASH_BLANK_S1_S2_INTS                   = " "0 (FLASH_BLANK_S1_S2_INTS_FALSE),1 (FLASH_BLANK_S1_S2_INTS_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "BOB_MONITORING_CURRENT_TOO_HIGH2_TH"
      sgroup "BOB_MONITORING_CURRENT_TOO_HIGH2_TH (at 0x1a153)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ILIM_TH                                  = " "0 (ILIM_TH_1A),1 (ILIM_TH_1A5),2 (ILIM_TH_2A),3 (ILIM_TH_2A5),4 (ILIM_TH_3A),5 (ILIM_TH_3A5),6 (ILIM_TH_4A),7 (ILIM_TH_4A5)"
    tree.end
    tree "BOB_MONITORING_CURRENT_TOO_HIGH2_CNT"
      sgroup "BOB_MONITORING_CURRENT_TOO_HIGH2_CNT (at 0x1a154)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ILIM_CNT_HIT                             = " "0 (ILIM_CNT_HIT_1CLK),1 (ILIM_CNT_HIT_2CLK),2 (ILIM_CNT_HIT_4CLK),3 (ILIM_CNT_HIT_8CLK),4 (ILIM_CNT_HIT_16CLK),5 (ILIM_CNT_HIT_24CLK),6 (ILIM_CNT_HIT_32CLK),7 (ILIM_CNT_HIT_64CLK)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ILIM_CNT_CLEAR                           = " "0 (ILIM_CNT_CLEAR_1CLK),1 (ILIM_CNT_CLEAR_2CLK),2 (ILIM_CNT_CLEAR_4CLK),3 (ILIM_CNT_CLEAR_8CLK),4 (ILIM_CNT_CLEAR_16CLK),5 (ILIM_CNT_CLEAR_24CLK),6 (ILIM_CNT_CLEAR_32CLK),7 (ILIM_CNT_CLEAR_64CLK)"
    tree.end
    tree "BOB_MONITORING_CURRENT_TOO_HIGH1_TH"
      sgroup "BOB_MONITORING_CURRENT_TOO_HIGH1_TH (at 0x1a156)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ILIM_S1_TH                               = " "0 (ILIM_S1_TH_3A),1 (ILIM_S1_TH_3A25),2 (ILIM_S1_TH_3A5),3 (ILIM_S1_TH_3A75)"
    tree.end
    tree "BOB_MONITORING_CURRENT_HIGH_TH"
      sgroup "BOB_MONITORING_CURRENT_HIGH_TH (at 0x1a159)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ILIM_S2_TH                               = " "0 (ILIM_S2_TH_2A5),1 (ILIM_S2_TH_2A75),2 (ILIM_S2_TH_3A),3 (ILIM_S2_TH_3A25)"
    tree.end
    tree "BOB_MONITORING_ILIM_S1_S2_EN"
      sgroup "BOB_MONITORING_ILIM_S1_S2_EN (at 0x1a15c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a15c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa15c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_S1_S2_EN                            = " "0 (ILIM_S1_S2_EN_FALSE),1 (ILIM_S1_S2_EN_TRUE)"
    tree.end
    tree "BOB_MONITORING_SEC_ACCESS"
      sgroup "BOB_MONITORING_SEC_ACCESS (at 0x1a1d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BOB_MONITORING_INT_TEST1"
      sgroup "BOB_MONITORING_INT_TEST1 (at 0x1a1e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BOB_MONITORING_INT_TEST_VAL"
      sgroup "BOB_MONITORING_INT_TEST_VAL (at 0x1a1e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   THERM_OVLD_TEST_VAL                      = " "0 (THERM_OVLD_TEST_VAL_0),1 (THERM_OVLD_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DERATE_LEVEL2_TEST_VAL                   = " "0 (DERATE_LEVEL2_TEST_VAL_0),1 (DERATE_LEVEL2_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_LEVEL1_TEST_VAL                   = " "0 (DERATE_LEVEL1_TEST_VAL_0),1 (DERATE_LEVEL1_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_LEVEL0_TEST_VAL                   = " "0 (DERATE_LEVEL0_TEST_VAL_0),1 (DERATE_LEVEL0_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BOB_CURRENT_TOO_HIGH2_TEST_VAL           = " "0 (BOB_CURRENT_TOO_HIGH2_TEST_VAL_0),1 (BOB_CURRENT_TOO_HIGH2_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BOB_CURRENT_TOO_HIGH1_TEST_VAL           = " "0 (BOB_CURRENT_TOO_HIGH1_TEST_VAL_0),1 (BOB_CURRENT_TOO_HIGH1_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BOB_CURRENT_HIGH_TEST_VAL                = " "0 (BOB_CURRENT_HIGH_TEST_VAL_0),1 (BOB_CURRENT_HIGH_TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "BSI"
  tree "BSI"
    tree "BSI_REVISION1"
      sgroup "BSI_REVISION1 (at 0x1b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BSI_REVISION2"
      sgroup "BSI_REVISION2 (at 0x1b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BSI_REVISION3"
      sgroup "BSI_REVISION3 (at 0x1b02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BSI_REVISION4"
      sgroup "BSI_REVISION4 (at 0x1b03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BSI_PERPH_TYPE"
      sgroup "BSI_PERPH_TYPE (at 0x1b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BSI_PERPH_SUBTYPE"
      sgroup "BSI_PERPH_SUBTYPE (at 0x1b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BSI_BSI_STS"
      sgroup "BSI_BSI_STS (at 0x1b08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BSI_ACTIVE                               = " "0 (BSI_NOT_ACTIVE),1 (BSI_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BSI_TX_DISABLE                           = " "0 (TX_ENABLED),1 (TX_DISABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_ERR_FLAG                        = " "0 (OK),1 (ERROR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MIPI_BIF_TX_BUSY                         = " "0 (TX_IDLE),1 (TX_BUSY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_RX_BUSY                         = " "0 (RX_IDLE),1 (RX_BUSY)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_TX_GO_STATUS                    = " "0 (TX_GO_CLEAR),1 (TX_GO_SET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_RX_FLOW_STATUS                  = " "0 (NO_RX_DATA),1 (RX_DATA_AVAIL)"
    tree.end
    tree "BSI_MIPI_BIF_FSM_STS"
      sgroup "BSI_MIPI_BIF_FSM_STS (at 0x1b09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MIPI_BIF_TX_FSM                          = " "0 (TX_IDLE),1 (TX_DATA_STATE),2 (TX_STOP),3 (TX_BAT_IRQ),4 (TX_PUL),5 (TX_WAIT_CLR_ERR),6 (TX_DLY_STATE),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MIPI_BIF_RX_FSM                          = " "0 (RX_IDLE),1 (RX_BCF),2 (RX_NOT_BCF),3 (RX_DATA_STATE),4 (RX_STOP),5 (RX_BAT_IRQ),6 (RX_WAIT_CLR_ERR),7 (reserved)"
    tree.end
    tree "BSI_RX_FIFO_STS"
      sgroup "BSI_RX_FIFO_STS (at 0x1b0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   WORD_NUM                                 = "
    tree.end
    tree "BSI_BSI_BAT_STS"
      sgroup "BSI_BSI_BAT_STS (at 0x1b0d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b0d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b0d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_MISS_DEB                             = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISS_RAW                             = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_DEB_PRES_STATUS                      = " "0 (BATT_PRESENT),1 (BATT_GONE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_NODEB_PRES_STATUS                    = " "0 (BATT_PRESENT),1 (BATT_GONE)"
    tree.end
    tree "BSI_INT_RT_STS"
      sgroup "BSI_INT_RT_STS (at 0x1b10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_RT_STS                      = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_RT_STS                    = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_RT_STS                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_RT_STS                  = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "BSI_INT_SET_TYPE"
      sgroup "BSI_INT_SET_TYPE (at 0x1b11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_SET_TYPE                    = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_SET_TYPE                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_SET_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_SET_TYPE                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_SET_TYPE                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "BSI_INT_POLARITY_HIGH"
      sgroup "BSI_INT_POLARITY_HIGH (at 0x1b12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_POLARITY_HIGH               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_POLARITY_HIGH             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_POLARITY_HIGH                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_POLARITY_HIGH            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_POLARITY_HIGH            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_POLARITY_HIGH           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "BSI_INT_POLARITY_LOW"
      sgroup "BSI_INT_POLARITY_LOW (at 0x1b13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_POLARITY_LOW                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_POLARITY_LOW              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_POLARITY_LOW                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_POLARITY_LOW             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_POLARITY_LOW             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_POLARITY_LOW            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "BSI_INT_LATCHED_CLR"
      sgroup "BSI_INT_LATCHED_CLR (at 0x1b14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_LATCHED_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "BSI_INT_EN_SET"
      sgroup "BSI_INT_EN_SET (at 0x1b15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_EN_SET                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BSI_INT_EN_CLR"
      sgroup "BSI_INT_EN_CLR (at 0x1b16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_EN_CLR                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "BSI_INT_LATCHED_STS"
      sgroup "BSI_INT_LATCHED_STS (at 0x1b18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_LATCHED_STS             = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "BSI_INT_PENDING_STS"
      sgroup "BSI_INT_PENDING_STS (at 0x1b19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_PENDING_STS             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "BSI_INT_MID_SEL"
      sgroup "BSI_INT_MID_SEL (at 0x1b1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "BSI_INT_PRIORITY"
      sgroup "BSI_INT_PRIORITY (at 0x1b1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "BSI_BSI_EN"
      sgroup "BSI_BSI_EN (at 0x1b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BSI_EN                                   = " "0 (BSI_DISABLED),1 (BSI_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_ERR_CLEAR"
      sgroup "BSI_MIPI_BIF_ERR_CLEAR (at 0x1b4f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_CLEAR_ERR                       = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_FSM_RESET"
      sgroup "BSI_MIPI_BIF_FSM_RESET (at 0x1b50)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_FSM_RESET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MIPI_BIF_RX_FIFO_RESET                   = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_FORCE_BCL_LOW"
      sgroup "BSI_MIPI_BIF_FORCE_BCL_LOW (at 0x1b51)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_FORCE_BCL_LOW                   = " "0 (BCL_RELEASED),1 (BCL_FORCED_LOW)"
    tree.end
    tree "BSI_MIPI_BIF_TAU_CFG"
      sgroup "BSI_MIPI_BIF_TAU_CFG (at 0x1b52)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_SAMPLE_RATE                     = " "0 (SAMPLE_RATE_4X),1 (SAMPLE_RATE_8X)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MIPI_BIF_SEL_TAU                         = " "0 (TAU_150US),1 (TAU_122US),2 (TAU_62US),3 (TAU_32US),4 (TAU_16US),5 (TAU_8US),6 (TAU_4US),7 (TAU_2US)"
    tree.end
    tree "BSI_MIPI_BIF_MODE"
      sgroup "BSI_MIPI_BIF_MODE (at 0x1b53)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_TX_PULSE_MODE                   = " "0 (TX_DATA_MODE),1 (TX_PULSE_MODE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MIPI_BIF_RX_PULSE_MODE                   = " "0 (RX_DATA_MODE),1 (RX_PULSE_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_PULSE_TYPE                   = " "0 (TX_PULSE_1_TAU),1 (TX_PULSE_240US)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_DATA_FORMAT                  = " "0 (RX_11BIT_MODE),1 (RX_17BIT_MODE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_TX_DATA_FORMAT                  = " "0 (TX_11BIT_MODE),1 (TX_17BIT_MODE)"
    tree.end
    tree "BSI_MIPI_BIF_EN"
      sgroup "BSI_MIPI_BIF_EN (at 0x1b54)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_TX_EN                           = " "0 (TX_DISABLED),1 (TX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MIPI_BIF_RX_EN                           = " "0 (RX_DISABLED),1 (RX_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_CFG"
      sgroup "BSI_MIPI_BIF_CFG (at 0x1b55)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MIPI_BIF_PU_EN                           = " "0 (PULLUP_DISABLED),1 (PULLUP_ENABLED)"
    tree.end
    tree "BSI_MIPI_BIF_RX_CFG"
      sgroup "BSI_MIPI_BIF_RX_CFG (at 0x1b56)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FIFO_EN                                  = " "0 (FIFO_DISABLED),1 (FIFO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_IRQ_FREQ                              = " "0 (FREQ_1_WORD),1 (FREQ_2_WORDS),2 (FREQ_3_WORDS),3 (FREQ_4_WORDS),4 (FREQ_5_WORDS),5 (FREQ_6_WORDS),6 (FREQ_7_WORDS),7 (FREQ_8_WORDS)"
    tree.end
    tree "BSI_MIPI_BIF_TX_DLY"
      sgroup "BSI_MIPI_BIF_TX_DLY (at 0x1b59)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIPI_BIF_TX_DLY                          = " "0 (DLY_0_TAU),1 (DLY_5_TAU),2 (DLY_10_TAU),3 (DLY_15_TAU)"
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_0"
      sgroup "BSI_MIPI_BIF_DATA_TX_0 (at 0x1b5a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_TX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_1"
      sgroup "BSI_MIPI_BIF_DATA_TX_1 (at 0x1b5b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_TX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_TX_2"
      sgroup "BSI_MIPI_BIF_DATA_TX_2 (at 0x1b5c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_DATA_TX                         = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_TX_CTL"
      sgroup "BSI_MIPI_BIF_TX_CTL (at 0x1b5d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_TX_GO                           = " "0, 1"
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_0"
      sgroup "BSI_MIPI_BIF_DATA_RX_0 (at 0x1b60)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_RX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_1"
      sgroup "BSI_MIPI_BIF_DATA_RX_1 (at 0x1b61)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MIPI_BIF_DATA_RX                         = "
    tree.end
    tree "BSI_MIPI_BIF_DATA_RX_2"
      sgroup "BSI_MIPI_BIF_DATA_RX_2 (at 0x1b62)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MIPI_BIF_DATA_LOOPBACK_TAG               = " "0 (NORMAL_DATA),1 (LOOPBACK_DATA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_DATA_RX                         = " "0, 1"
    tree.end
    tree "BSI_RX_FIFO_WORD1_0"
      sgroup "BSI_RX_FIFO_WORD1_0 (at 0x1b63)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD1_1"
      sgroup "BSI_RX_FIFO_WORD1_1 (at 0x1b64)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD2_0"
      sgroup "BSI_RX_FIFO_WORD2_0 (at 0x1b65)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD2_1"
      sgroup "BSI_RX_FIFO_WORD2_1 (at 0x1b66)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD3_0"
      sgroup "BSI_RX_FIFO_WORD3_0 (at 0x1b67)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD3_1"
      sgroup "BSI_RX_FIFO_WORD3_1 (at 0x1b68)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_RX_FIFO_WORD4_0"
      sgroup "BSI_RX_FIFO_WORD4_0 (at 0x1b69)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RX_DATA                                  = "
    tree.end
    tree "BSI_RX_FIFO_WORD4_1"
      sgroup "BSI_RX_FIFO_WORD4_1 (at 0x1b6a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DATA_VALID                               = " "0 (DATA_NOT_VALID),1 (DATA_VALID)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ERROR_FLAG                               = " "0 (DATA_OK),1 (DATA_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RX_DATA                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BSI_MIPI_BIF_BCL_RAW"
      sgroup "BSI_MIPI_BIF_BCL_RAW (at 0x1b6d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b6d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_BCL_RAW                         = " "0 (BCL_STATE_LOW),1 (BCL_STATE_HIGH)"
    tree.end
    tree "BSI_MIPI_BIF_ERROR"
      sgroup "BSI_MIPI_BIF_ERROR (at 0x1b70)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MIPI_BIF_ERROR_CODE                      = "
    tree.end
    tree "BSI_BAT_GONE_CFG"
      sgroup "BSI_BAT_GONE_CFG (at 0x1ba7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801ba70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ba70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_GONE_SEL                             = " "0 (NON_DEBOUNCED),1 (DEBOUNCED)"
    tree.end
    tree "BSI_BAT_RMV_DEB_TIMER"
      sgroup "BSI_BAT_RMV_DEB_TIMER (at 0x1ba8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801ba80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ba80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RMV_TIMER                                = "
    tree.end
    tree "BSI_BAT_PRES_DEB_TIMER"
      sgroup "BSI_BAT_PRES_DEB_TIMER (at 0x1ba9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801ba90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ba90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PRES_TIMER                               = "
    tree.end
    tree "BSI_BAT_GONE_DLY"
      sgroup "BSI_BAT_GONE_DLY (at 0x1baa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801baa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1baa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DLY_CFG                                  = " "0 (BYPASSED),1 (DLY_10U3),2 (DLY_15U6),3 (DLY_19U6)"
    tree.end
    tree "BSI_SEC_ACCESS"
      sgroup "BSI_SEC_ACCESS (at 0x1bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BSI_PERPH_RESET_CTL2"
      sgroup "BSI_PERPH_RESET_CTL2 (at 0x1bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BSI_PERPH_RESET_CTL3"
      sgroup "BSI_PERPH_RESET_CTL3 (at 0x1bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BSI_PERPH_RESET_CTL4"
      sgroup "BSI_PERPH_RESET_CTL4 (at 0x1bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BSI_BSI_SPARE"
      sgroup "BSI_BSI_SPARE (at 0x1bdf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bdf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bdf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "BSI_INT_TEST1"
      sgroup "BSI_INT_TEST1 (at 0x1be0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "BSI_INT_TEST_VAL"
      sgroup "BSI_INT_TEST_VAL (at 0x1be1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_BAT_PRES_INT_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NODEB_BAT_PRES_INT_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TX_DISABLE_INT_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MIPI_BIF_TX_INT_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MIPI_BIF_RX_INT_VAL                      = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MIPI_BIF_ERR_INT_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "BSI_TEST1"
      sgroup "BSI_TEST1 (at 0x1be2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
    tree.end
    tree "BSI_TEST2"
      sgroup "BSI_TEST2 (at 0x1be3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   BSI_DTEST_SEL                            = "
    tree.end
    tree "BSI_MIPI_BIF_TX_ATE_CTL"
      sgroup "BSI_MIPI_BIF_TX_ATE_CTL (at 0x1be4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_GO_ATE                                = " "0, 1"
    tree.end
    tree "BSI_BSI_TEST"
      sgroup "BSI_BSI_TEST (at 0x1be5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TX_DISABLE_TEST                          = " "0 (NORMAL),1 (IGNORED)"
    tree.end
  tree.end
tree.end
tree "BUA"
  tree "BUA"
    tree "BUA_REVISION1"
      sgroup "BUA_REVISION1 (at 0x1c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_REVISION2"
      sgroup "BUA_REVISION2 (at 0x1c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_REVISION3"
      sgroup "BUA_REVISION3 (at 0x1c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BUA_REVISION4"
      sgroup "BUA_REVISION4 (at 0x1c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BUA_PERPH_TYPE"
      sgroup "BUA_PERPH_TYPE (at 0x1c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_PERPH_SUBTYPE"
      sgroup "BUA_PERPH_SUBTYPE (at 0x1c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_STATUS1"
      sgroup "BUA_STATUS1 (at 0x1c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_OK                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
    tree.end
    tree "BUA_BUA_CTL1"
      sgroup "BUA_BUA_CTL1 (at 0x1c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0 (SCLK_0_TO_1),1 (SCLK_1_TO_2),2 (SCLK_2_TO_3),3 (SCLK_5_TO_6),4 (SCLK_8_TO_9),5 (SCLK_11_TO_12),6 (SCLK_15_TO_16),7 (SCLK_31_TO_32)"
    tree.end
    tree "BUA_EN_CTL1"
      sgroup "BUA_EN_CTL1 (at 0x1c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0 (BUA_DISABLED),1 (BUA_ENABLED)"
    tree.end
    tree "BUA_SEC_ACCESS"
      sgroup "BUA_SEC_ACCESS (at 0x1cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_PERPH_RESET_CTL1"
      sgroup "BUA_PERPH_RESET_CTL1 (at 0x1cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BUA_PERPH_RESET_CTL2"
      sgroup "BUA_PERPH_RESET_CTL2 (at 0x1cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL3"
      sgroup "BUA_PERPH_RESET_CTL3 (at 0x1cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_PERPH_RESET_CTL4"
      sgroup "BUA_PERPH_RESET_CTL4 (at 0x1cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUA_TEST1"
      sgroup "BUA_TEST1 (at 0x1ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LOGGER_OK                                = " "0 (LOGGER_INACTIVE),1 (LOGGER_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LOGGER_FULL                              = " "0 (LOGGER_NOT_FULL),1 (LOGGER_IS_FULL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HALF_ENTRY                               = " "0 (FULL_ENTRIES),1 (LAST_HALF_ENTRY)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_FIFO_SIZE"
      sgroup "BUS_FIFO_SIZE (at 0x40b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80040b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FIFO_SIZE                                = " "0 (FIFO64X64),1 (FIFO128X64),2 (FIFO256X64),3 (reserved)"
    tree.end
    tree "BUS_TIMEOUT_EN"
      sgroup "BUS_TIMEOUT_EN (at 0x443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMEOUT_EN                               = " "0, 1"
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TIMEOUT                                  = "
    tree.end
    tree "BUS_LOGGER_EN"
      sgroup "BUS_LOGGER_EN (at 0x446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LOGGER_EN                                = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "BUS_LOGGER_CTL"
      sgroup "BUS_LOGGER_CTL (at 0x450)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PERPH_FILTER                             = " "0 (PERPH_FILTER_OFF),1 (PERPH_FILTER_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IGNORE_TIMESTAMP                         = " "0 (LOG_TIMESTAMP),1 (IGNORE_TIMESTAMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IGNORE_READS                             = " "0 (LOG_READS_AND_WRITES),1 (LOG_WRITES_ONLY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WRAP                                     = " "0 (NO_WRAP),1 (WRAP)"
    tree.end
    tree "BUS_LOGGER_PID"
      sgroup "BUS_LOGGER_PID (at 0x452)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOGGER_PID                               = "
    tree.end
    tree "BUS_LOGGER_SID"
      sgroup "BUS_LOGGER_SID (at 0x453)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOGGER_SID                               = " "0, 1, 2, 3"
    tree.end
    tree "BUS_MEM_INTF_ADDR"
      sgroup "BUS_MEM_INTF_ADDR (at 0x454)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR                            = "
    tree.end
    tree "BUS_CAPTURE_INC"
      sgroup "BUS_CAPTURE_INC (at 0x456)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAPTURE_INC                              = " "0 (reserved),1 (CAPTURE_AND_INC)"
    tree.end
    tree "BUS_MEM_INTF_DATA0"
      sgroup "BUS_MEM_INTF_DATA0 (at 0x458)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA0                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA1"
      sgroup "BUS_MEM_INTF_DATA1 (at 0x459)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA1                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA2"
      sgroup "BUS_MEM_INTF_DATA2 (at 0x45a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA2                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA3"
      sgroup "BUS_MEM_INTF_DATA3 (at 0x45b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA3                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA4"
      sgroup "BUS_MEM_INTF_DATA4 (at 0x45c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA4                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA5"
      sgroup "BUS_MEM_INTF_DATA5 (at 0x45d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA5                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA6"
      sgroup "BUS_MEM_INTF_DATA6 (at 0x45e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA6                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA7"
      sgroup "BUS_MEM_INTF_DATA7 (at 0x45f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA7                           = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL1"
      sgroup "BUS_PERPH_RESET_CTL1 (at 0x4d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HFRC_OK                                  = " "0 (HFRC_OFF),1 (HFRC_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   IDSS_REQ_XO                              = " "0 (NOT_REQUEST_XO),1 (REQUEST_XO)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HF_GP_SEL_STATUS                         = " "0 (SEL_HFRC),1 (SEL_XO)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HF_SMPS_SEL_STATUS                       = " "0 (SEL_HFRC),1 (SEL_XO)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SLP_CLK_PAD_VREG_OK                      = " "0 (SLP_CLK_PAD_VREG_NOT_OK),1 (SLP_CLK_PAD_VREG_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLP_CLK_SOURCE                           = " "0 (RESERVED_0),1 (EXT_32K),2 (CALRC1),3 (LFRC_DIV2),4 (RESERVED_4),5 (XO_DIV),6 (RESERVED_6),7 (AON_32K)"
    tree.end
    tree "CLK_DIST_STATUS2"
      sgroup "CLK_DIST_STATUS2 (at 0x5909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SMPS_GP_REQ                              = "
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_RT_STS                   = " "0 (SLP_CLK_NOT_HALT),1 (SLP_CLK_HALT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_RT_STS                       = " "0 (XO_NOT_HALT),1 (XO_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_BASE_ON_WARM_SLEEP_B_AND_HF_HALT_B),1 (SMPS_CLK_HFRC),2 (SMPS_CLK_XO),3 (SMPS_CLK_BASE_ON_HALT_B)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_SEL                                = " "0 (GP_CLK_BASE_ON_WARM_SLEEP_B_AND_HF_HALT_B),1 (GP_CLK_HFRC),2 (GP_CLK_XO),3 (GP_CLK_BASE_ON_HALT_B)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0 (ALT_SC_DIVIDER_DIS),1 (ALT_SC_DIVIDER_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EXT32K_DIV_SEL                           = " "0 (DIV32768),1 (DIV32764)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EXT32K_CLK_SEL                           = " "0 (CALRC),1 (EXT32K)"
    tree.end
    tree "CLK_DIST_CLK_CTL5"
      sgroup "CLK_DIST_CLK_CTL5 (at 0x5944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_32K_SEL                              = " "0 (FOLLOW_32K_HALT),1 (LFRC_AON),2 (CLK_32K_SOURCE),3 (reserved)"
    tree.end
    tree "CLK_DIST_XO_HALT_CTL"
      sgroup "CLK_DIST_XO_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_HW_XO_HALT                        = " "0 (NOT_FOLLOW_HW_XO_HALT),1 (FOLLOW_HW_XO_HALT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO_HALT                            = " "0 (XO_HALT_NOT_FORCED),1 (XO_HALT_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO_HALT                             = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_HFRC_CTL"
      sgroup "CLK_DIST_HFRC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_HFRC_OSC_ON                        = " "0 (HFRC_NOT_FORCED),1 (HFRC_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HFRC_OSC_HW_CTL                          = " "0 (HFRC_NOT_FOLLOW_HW_DEMAND),1 (HFRC_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_CLK32K_HALT_CTL"
      sgroup "CLK_DIST_CLK32K_HALT_CTL (at 0x5947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_HW_CLK32K_HALT                    = " "0 (NOT_FOLLOW_HW_CLK32K_HALT),1 (FOLLOW_HW_CLK32K_HALT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_CLK32K_HALT                        = " "0 (CLK32K_HALT_NOT_FORCED),1 (CLK32K_HALT_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_CLK32K_HALT                         = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_CLK98K_CTL"
      sgroup "CLK_DIST_CLK98K_CTL (at 0x5949)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_CLK98K                             = " "0 (CLK98K_NOT_FORCED),1 (CLK98K_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_CLK98K                         = " "0 (NOT_FOLLOW_HW_CLK98K_ENA),1 (FOLLOW_HW_CLK98K_ENA)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0 (NOT_FORCE_AWAKE),1 (FORCE_PMIC_AWAKE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (PMIC_AWAKE_NOT_FOLLOW_HW),1 (PMIC_AWAKE_FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_SMPS_GP_STATUS_SEL"
      sgroup "CLK_DIST_SMPS_GP_STATUS_SEL (at 0x594b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   STATUS_REQ_SEL                           = "
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_TEST_VAL                     = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (HF_CLK),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TEST3"
      sgroup "CLK_DIST_TEST3 (at 0x59e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   XO_BCKBLNK_SEL1                          = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_BCKBLNK_SEL0                          = "
    tree.end
    tree "CLK_DIST_TEST4"
      sgroup "CLK_DIST_TEST4 (at 0x59e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HFRC_TEST_EN                             = " "0 (HFRC_TEST_DISENA),1 (HFRC_TEST_ENA)"
    tree.end
    tree "CLK_DIST_TEST5"
      sgroup "CLK_DIST_TEST5 (at 0x59e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   XO_BCKBLNK_CLK_EN1                       = " "0 (XO_BCKBLNK_DISENA),1 (XO_BCKBLNK_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_BCKBLNK_CLK_EN0                       = " "0 (XO_BCKBLNK_DISENA),1 (XO_BCKBLNK_ENA)"
    tree.end
    tree "CLK_DIST_TEST6"
      sgroup "CLK_DIST_TEST6 (at 0x59e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST_SEL                                = " "0 (HIZ),1 (BCKBLNK_CLK0),2 (BCKBLNK_CLK1),3 (ZERO_3)"
    tree.end
    tree "CLK_DIST_TEST7"
      sgroup "CLK_DIST_TEST7 (at 0x59e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_GP_ENA                             = " "0 (NOT_FORCE),1 (FORCE_ENA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_GP_ENA                            = " "0 (NOT_FOLLOW_HW),1 (FOLLOW_HW)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_SMPS_ENA                           = " "0 (NOT_FORCE),1 (FORCE_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SMPS_ENA                          = " "0 (NOT_FOLLOW_HW),1 (FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_TEST8"
      sgroup "CLK_DIST_TEST8 (at 0x59ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TS_ENABLE                                = " "0 (TS_DISABLE),1 (TS_ENABLE)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_HFRC_TRIM"
      sgroup "CLK_DIST_HFRC_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   HFRC_TRIM                                = "
    tree.end
    tree "CLK_DIST_LFRC_AON_TRIM"
      sgroup "CLK_DIST_LFRC_AON_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LFRC_AON_TRIM                            = "
    tree.end
  tree.end
tree.end
tree "FG_ADC_RR"
  tree "FG_ADC_RR"
    tree "FG_ADC_RR_PERPH_TYPE"
      sgroup "FG_ADC_RR_PERPH_TYPE (at 0x4504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_ADC_RR_PERPH_SUBTYPE"
      sgroup "FG_ADC_RR_PERPH_SUBTYPE (at 0x4505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_ADC_RR_STATUS1"
      sgroup "FG_ADC_RR_STATUS1 (at 0x4508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RR_ADC_OK                                = " "0 (NOT_ACTIVE),1 (ACTIVE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LDO_STS                                  = " "0 (LDO_NOT_REQUESTED),1 (LDO_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BG_BUF_STS                               = " "0 (BG_BUFF_NOT_REQUESTED),1 (BG_BUFF_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BG_REQUEST_STS                           = " "0 (BG_NOT_REQUESTED),1 (BG_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BG_OK_STS                                = " "0 (BG_NOT_READYD),1 (BG_READY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_SHDN_ACK                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR_READY                                 = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_CHG_PWR_STS"
      sgroup "FG_ADC_RR_CHG_PWR_STS (at 0x4509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_PWR_SWITCHER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DC_IN_CONNECTED                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB_PWR_SWITCHER                         = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB_IN_CONNECTED                         = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_REF_STS"
      sgroup "FG_ADC_RR_REF_STS (at 0x450a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80450a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x450a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   REF_SELECTION                            = " "0 (REF_IS_RBIAS),1 (REF_IS_5_DIV_3_V),2 (REF_IS_5_DIV_2_V),3 (REF_IS_5_V)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   REF_REQUEST                              = " "0 (REF_NOT_REQUESTED),1 (REF_REQUESTED)"
    tree.end
    tree "FG_ADC_RR_RR_DATA_ACS_STS"
      sgroup "FG_ADC_RR_RR_DATA_ACS_STS (at 0x450b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80450b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x450b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RDY                                      = " "0, 1"
    tree.end
    tree "FG_ADC_RR_RR_DATA_ACS_LSB"
      sgroup "FG_ADC_RR_RR_DATA_ACS_LSB (at 0x450c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80450c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x450c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_ACS_LSB                             = "
    tree.end
    tree "FG_ADC_RR_RR_DATA_ACS_MSB"
      sgroup "FG_ADC_RR_RR_DATA_ACS_MSB (at 0x450d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80450d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x450d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA_ACS_MSB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_INT_RT_STS"
      sgroup "FG_ADC_RR_INT_RT_STS (at 0x4510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_ADC_RR_INT_SET_TYPE"
      sgroup "FG_ADC_RR_INT_SET_TYPE (at 0x4511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_ADC_RR_INT_POLARITY_HIGH"
      sgroup "FG_ADC_RR_INT_POLARITY_HIGH (at 0x4512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_RR_INT_POLARITY_LOW"
      sgroup "FG_ADC_RR_INT_POLARITY_LOW (at 0x4513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_ADC_RR_INT_LATCHED_CLR"
      sgroup "FG_ADC_RR_INT_LATCHED_CLR (at 0x4514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0, 1"
    tree.end
    tree "FG_ADC_RR_INT_EN_SET"
      sgroup "FG_ADC_RR_INT_EN_SET (at 0x4515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_RR_INT_EN_CLR"
      sgroup "FG_ADC_RR_INT_EN_CLR (at 0x4516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_ADC_RR_INT_LATCHED_STS"
      sgroup "FG_ADC_RR_INT_LATCHED_STS (at 0x4518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_ADC_RR_INT_PENDING_STS"
      sgroup "FG_ADC_RR_INT_PENDING_STS (at 0x4519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_ADC_RR_INT_MID_SEL"
      sgroup "FG_ADC_RR_INT_MID_SEL (at 0x451a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_ADC_RR_INT_PRIORITY"
      sgroup "FG_ADC_RR_INT_PRIORITY (at 0x451b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_ADC_RR_EN_CTL"
      sgroup "FG_ADC_RR_EN_CTL (at 0x4546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RR_ADC_EN                                = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_SKIN_TEMPERATURE_LSB"
      sgroup "FG_ADC_RR_SKIN_TEMPERATURE_LSB (at 0x4550)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_ADC_RR_SKIN_TEMPERATURE_MSB"
      sgroup "FG_ADC_RR_SKIN_TEMPERATURE_MSB (at 0x4551)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VALUE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_RR_ADC_CTL"
      sgroup "FG_ADC_RR_RR_ADC_CTL (at 0x4552)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CONTINOUS_SEQUENCE_INITIATE              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_SHDN                                  = " "0 (SHDN_NOT_REQUESTED),1 (SHDN_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SW_SEQUENCE_INITIATE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_SEQUENCE_INITIATE_EN                  = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_RR_ADC_LOG"
      sgroup "FG_ADC_RR_RR_ADC_LOG (at 0x4553)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   RR_DATA_ACS_ADDR                         = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR_DATA_ACS_REQ_TGL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLR_CTRL                                 = " "0 (DO_NOT_CLEAR),1 (CLEAR)"
    tree.end
    tree "FG_ADC_RR_REF_CFG"
      sgroup "FG_ADC_RR_REF_CFG (at 0x4554)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VREG_FG_BYPASS                           = " "0 (NO_CAP),1 (CAP_CONNECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VREG_FG_LEVEL                            = " "0 (VREG_FG_2P70_V),1 (VREG_FG_2P57_V),2 (VREG_FG_2P45_V),3 (VREG_FG_2P35_V),4 (VREG_FG_2P84_V),5 (VREG_FG_3P00_V),6 (VREG_FG_3P18_V),7 (VREG_FG_3P38_V)"
    tree.end
    tree "FG_ADC_RR_RBIAS_CNLS"
      sgroup "FG_ADC_RR_RBIAS_CNLS (at 0x4555)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BUFFER_SEL                               = " "0 (RBIAS_REF_UNBUF),1 (RBIAS_REF_BUF)"
    tree.end
    tree "FG_ADC_RR_FAKE_BATT_LOW_LSB"
      sgroup "FG_ADC_RR_FAKE_BATT_LOW_LSB (at 0x4558)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_ADC_RR_FAKE_BATT_LOW_MSB"
      sgroup "FG_ADC_RR_FAKE_BATT_LOW_MSB (at 0x4559)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VALUE                                    = " "0, 1, 2, 3"
    tree.end
    tree "FG_ADC_RR_FAKE_BATT_HIGH_LSB"
      sgroup "FG_ADC_RR_FAKE_BATT_HIGH_LSB (at 0x455a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80455a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x455a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_ADC_RR_FAKE_BATT_HIGH_MSB"
      sgroup "FG_ADC_RR_FAKE_BATT_HIGH_MSB (at 0x455b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80455b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x455b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VALUE                                    = " "0, 1, 2, 3"
    tree.end
    tree "FG_ADC_RR_BATT_ID_CTRL"
      sgroup "FG_ADC_RR_BATT_ID_CTRL (at 0x4560)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_BATT_ID_TRIGGER"
      sgroup "FG_ADC_RR_BATT_ID_TRIGGER (at 0x4561)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_CTRL                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_BATT_ID_STS"
      sgroup "FG_ADC_RR_BATT_ID_STS (at 0x4562)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAKE_BATTERY                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_BATT_ID_CFG"
      sgroup "FG_ADC_RR_BATT_ID_CFG (at 0x4563)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BIAS_WAIT                                = " "0 (BIASWAIT_0_MS),1 (BIASWAIT_1_MS),2 (BIASWAIT_4_MS),3 (BIASWAIT_12_MS),4 (BIASWAIT_20_MS),5 (BIASWAIT_40_MS),6 (BIASWAIT_60_MS),7 (BIASWAIT_80_MS)"
    tree.end
    tree "FG_ADC_RR_BATT_ID_5_LSB"
      sgroup "FG_ADC_RR_BATT_ID_5_LSB (at 0x4566)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_BATT_ID_5_MSB"
      sgroup "FG_ADC_RR_BATT_ID_5_MSB (at 0x4567)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_BATT_ID_15_LSB"
      sgroup "FG_ADC_RR_BATT_ID_15_LSB (at 0x4568)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_BATT_ID_15_MSB"
      sgroup "FG_ADC_RR_BATT_ID_15_MSB (at 0x4569)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_BATT_ID_150_LSB"
      sgroup "FG_ADC_RR_BATT_ID_150_LSB (at 0x456a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80456a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x456a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_BATT_ID_150_MSB"
      sgroup "FG_ADC_RR_BATT_ID_150_MSB (at 0x456b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80456b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x456b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_BATT_THERM_CTRL"
      sgroup "FG_ADC_RR_BATT_THERM_CTRL (at 0x4570)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_BATT_THERM_TRIGGER"
      sgroup "FG_ADC_RR_BATT_THERM_TRIGGER (at 0x4571)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_CTRL                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_BATT_THERM_STS"
      sgroup "FG_ADC_RR_BATT_THERM_STS (at 0x4572)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BATT_THERM_RBIAS_STS                     = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_BATT_THERM_CFG"
      sgroup "FG_ADC_RR_BATT_THERM_CFG (at 0x4573)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BIAS_WAIT                                = " "0 (BIASWAIT_0_MS),1 (BIASWAIT_1_MS),2 (BIASWAIT_4_MS),3 (BIASWAIT_12_MS),4 (BIASWAIT_20_MS),5 (BIASWAIT_40_MS),6 (BIASWAIT_60_MS),7 (BIASWAIT_80_MS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GND_SEL                                  = " "0 (SYSTEM_GROUND),1 (BATT_N)"
    tree.end
    tree "FG_ADC_RR_BATT_THERM_LSB"
      sgroup "FG_ADC_RR_BATT_THERM_LSB (at 0x4574)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_BATT_THERM_MSB"
      sgroup "FG_ADC_RR_BATT_THERM_MSB (at 0x4575)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_BATT_THERM_FREQ"
      sgroup "FG_ADC_RR_BATT_THERM_FREQ (at 0x4576)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_ADC_RR_AUX_THERM_CTRL"
      sgroup "FG_ADC_RR_AUX_THERM_CTRL (at 0x4580)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUX_CMP_CLEAR                            = " "0 (DO_NOT_CLEAR),1 (CLEAR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_AUX_THERM_TRIGGER"
      sgroup "FG_ADC_RR_AUX_THERM_TRIGGER (at 0x4581)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_AUX_THERM_STS"
      sgroup "FG_ADC_RR_AUX_THERM_STS (at 0x4582)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AUX_THERM_RBIAS_STS                      = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SKIN_TEMP_STS                            = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SKIN_TOO_HOT_STS                         = " "0 (SKIN_TEMP_BELOW),1 (SKIN_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SKIN_HOT_STS                             = " "0 (SKIN_TEMP_BELOW),1 (SKIN_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_AUX_THERM_CFG"
      sgroup "FG_ADC_RR_AUX_THERM_CFG (at 0x4583)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BIAS_WAIT                                = " "0 (BIASWAIT_0_MS),1 (BIASWAIT_1_MS),2 (BIASWAIT_4_MS),3 (BIASWAIT_12_MS),4 (BIASWAIT_20_MS),5 (BIASWAIT_40_MS),6 (BIASWAIT_60_MS),7 (BIASWAIT_80_MS)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AUX_TMP_HYST                             = " "0 (NO_HYSTERESIS),1 (HYST_1_C),2 (HYST_2_C),3 (HYST_3_C)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_THERM_SYNC                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AUX_THERM_MODE                           = " "0 (SKIN),1 (AUX)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GND_SEL                                  = " "0 (SYSTEM_GROUND),1 (BATT_N)"
    tree.end
    tree "FG_ADC_RR_AUX_THERM_LSB"
      sgroup "FG_ADC_RR_AUX_THERM_LSB (at 0x4584)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_AUX_THERM_MSB"
      sgroup "FG_ADC_RR_AUX_THERM_MSB (at 0x4585)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_SKIN_HOT"
      sgroup "FG_ADC_RR_SKIN_HOT (at 0x4586)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_ADC_RR_SKIN_TOO_HOT"
      sgroup "FG_ADC_RR_SKIN_TOO_HOT (at 0x4587)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_ADC_RR_AUX_THERM_C1"
      sgroup "FG_ADC_RR_AUX_THERM_C1 (at 0x4588)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COEFF_VALUE                              = "
    tree.end
    tree "FG_ADC_RR_AUX_THERM_C2"
      sgroup "FG_ADC_RR_AUX_THERM_C2 (at 0x4589)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COEFF_VALUE                              = "
    tree.end
    tree "FG_ADC_RR_AUX_THERM_C3"
      sgroup "FG_ADC_RR_AUX_THERM_C3 (at 0x458a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80458a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x458a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COEFF_VALUE                              = "
    tree.end
    tree "FG_ADC_RR_AUX_THERM_HALF_RANGE"
      sgroup "FG_ADC_RR_AUX_THERM_HALF_RANGE (at 0x458b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80458b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x458b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEMP_VALUE                               = "
    tree.end
    tree "FG_ADC_RR_USB_IN_V_CTRL"
      sgroup "FG_ADC_RR_USB_IN_V_CTRL (at 0x4590)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_USB_IN_V_TRIGGER"
      sgroup "FG_ADC_RR_USB_IN_V_TRIGGER (at 0x4591)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_USB_IN_V_STS"
      sgroup "FG_ADC_RR_USB_IN_V_STS (at 0x4592)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_USB_IN_V_LSB"
      sgroup "FG_ADC_RR_USB_IN_V_LSB (at 0x4594)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_USB_IN_V_MSB"
      sgroup "FG_ADC_RR_USB_IN_V_MSB (at 0x4595)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_USB_IN_I_CTRL"
      sgroup "FG_ADC_RR_USB_IN_I_CTRL (at 0x4598)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_USB_IN_I_TRIGGER"
      sgroup "FG_ADC_RR_USB_IN_I_TRIGGER (at 0x4599)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_USB_IN_I_STS"
      sgroup "FG_ADC_RR_USB_IN_I_STS (at 0x459a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80459a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x459a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_USB_IN_I_LSB"
      sgroup "FG_ADC_RR_USB_IN_I_LSB (at 0x459c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80459c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x459c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_USB_IN_I_MSB"
      sgroup "FG_ADC_RR_USB_IN_I_MSB (at 0x459d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80459d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x459d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_DC_IN_V_CTRL"
      sgroup "FG_ADC_RR_DC_IN_V_CTRL (at 0x45a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_DC_IN_V_TRIGGER"
      sgroup "FG_ADC_RR_DC_IN_V_TRIGGER (at 0x45a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_DC_IN_V_STS"
      sgroup "FG_ADC_RR_DC_IN_V_STS (at 0x45a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_DC_IN_V_LSB"
      sgroup "FG_ADC_RR_DC_IN_V_LSB (at 0x45a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_DC_IN_V_MSB"
      sgroup "FG_ADC_RR_DC_IN_V_MSB (at 0x45a5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_DC_IN_I_CTRL"
      sgroup "FG_ADC_RR_DC_IN_I_CTRL (at 0x45a8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_DC_IN_I_TRIGGER"
      sgroup "FG_ADC_RR_DC_IN_I_TRIGGER (at 0x45a9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_DC_IN_I_STS"
      sgroup "FG_ADC_RR_DC_IN_I_STS (at 0x45aa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_DC_IN_I_LSB"
      sgroup "FG_ADC_RR_DC_IN_I_LSB (at 0x45ac)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_DC_IN_I_MSB"
      sgroup "FG_ADC_RR_DC_IN_I_MSB (at 0x45ad)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ad0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_PMI_DIE_TEMP_CTRL"
      sgroup "FG_ADC_RR_PMI_DIE_TEMP_CTRL (at 0x45b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_PMI_DIE_TEMP_TRIGGER"
      sgroup "FG_ADC_RR_PMI_DIE_TEMP_TRIGGER (at 0x45b1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_PMI_DIE_TEMP_STS"
      sgroup "FG_ADC_RR_PMI_DIE_TEMP_STS (at 0x45b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_PMI_DIE_TEMP_CFG"
      sgroup "FG_ADC_RR_PMI_DIE_TEMP_CFG (at 0x45b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BIAS_WAIT                                = " "0 (BIASWAIT_0_MS),1 (BIASWAIT_1_MS),2 (BIASWAIT_4_MS),3 (BIASWAIT_12_MS),4 (BIASWAIT_20_MS),5 (BIASWAIT_40_MS),6 (BIASWAIT_60_MS),7 (BIASWAIT_80_MS)"
    tree.end
    tree "FG_ADC_RR_PMI_DIE_TEMP_LSB"
      sgroup "FG_ADC_RR_PMI_DIE_TEMP_LSB (at 0x45b4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_PMI_DIE_TEMP_MSB"
      sgroup "FG_ADC_RR_PMI_DIE_TEMP_MSB (at 0x45b5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_CHARGER_TEMP_CTRL"
      sgroup "FG_ADC_RR_CHARGER_TEMP_CTRL (at 0x45b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_CHARGER_TEMP_TRIGGER"
      sgroup "FG_ADC_RR_CHARGER_TEMP_TRIGGER (at 0x45b9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_CHARGER_TEMP_STS"
      sgroup "FG_ADC_RR_CHARGER_TEMP_STS (at 0x45ba)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CHARGER_TOO_HOT_STS                      = " "0 (CHARGER_TEMP_BELOW),1 (CHARGER_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHARGER_HOT_STS                          = " "0 (CHARGER_TEMP_BELOW),1 (CHARGER_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_CHARGER_TEMP_CFG"
      sgroup "FG_ADC_RR_CHARGER_TEMP_CFG (at 0x45bb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045bb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45bb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   BIAS_WAIT                                = " "0 (BIASWAIT_0_MS),1 (BIASWAIT_1_MS),2 (BIASWAIT_4_MS),3 (BIASWAIT_12_MS),4 (BIASWAIT_20_MS),5 (BIASWAIT_40_MS),6 (BIASWAIT_60_MS),7 (BIASWAIT_80_MS)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   CHARGER_TMP_HYST                         = " "0 (NO_HYSTERESIS),1 (HYST_1_C),2 (HYST_2_C),3 (HYST_3_C)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TEMP_CMP_CLEAR                           = " "0 (DO_NOT_CLEAR),1 (CLEAR)"
    tree.end
    tree "FG_ADC_RR_CHARGER_TEMP_LSB"
      sgroup "FG_ADC_RR_CHARGER_TEMP_LSB (at 0x45bc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045bc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45bc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_CHARGER_TEMP_MSB"
      sgroup "FG_ADC_RR_CHARGER_TEMP_MSB (at 0x45bd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045bd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45bd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_CHARGER_HOT"
      sgroup "FG_ADC_RR_CHARGER_HOT (at 0x45be)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045be0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45be0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_ADC_RR_CHARGER_TOO_HOT"
      sgroup "FG_ADC_RR_CHARGER_TOO_HOT (at 0x45bf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045bf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45bf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_ADC_RR_GPIO_CTRL"
      sgroup "FG_ADC_RR_GPIO_CTRL (at 0x45c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_GPIO_TRIGGER"
      sgroup "FG_ADC_RR_GPIO_TRIGGER (at 0x45c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_GPIO_STS"
      sgroup "FG_ADC_RR_GPIO_STS (at 0x45c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_GPIO_LSB"
      sgroup "FG_ADC_RR_GPIO_LSB (at 0x45c4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_GPIO_MSB"
      sgroup "FG_ADC_RR_GPIO_MSB (at 0x45c5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_ATEST_CTRL"
      sgroup "FG_ADC_RR_ATEST_CTRL (at 0x45c8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_IRQ                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHANNEL_CONV                             = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_ATEST_TRIGGER"
      sgroup "FG_ADC_RR_ATEST_TRIGGER (at 0x45c9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045c90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EVERY_CYCLE                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_TRIGGER                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_HPM_TRIGGER                          = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_TRIGGER                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RFU_TRIGGER                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEEP_CONV_QUALIFIER                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_ADC_RR_ATEST_STS"
      sgroup "FG_ADC_RR_ATEST_STS (at 0x45ca)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ca0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ca0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHANNEL_STS                              = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   READING_STS                              = " "0 (NOT_AVAILABLE),1 (AVAILABLE)"
    tree.end
    tree "FG_ADC_RR_ATEST_LSB"
      sgroup "FG_ADC_RR_ATEST_LSB (at 0x45cc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045cc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45cc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_READ                                 = "
    tree.end
    tree "FG_ADC_RR_ATEST_MSB"
      sgroup "FG_ADC_RR_ATEST_MSB (at 0x45cd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045cd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45cd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADC_READ                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_SEC_ACCESS"
      sgroup "FG_ADC_RR_SEC_ACCESS (at 0x45d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_ADC_RR_PERPH_RESET_CTL2"
      sgroup "FG_ADC_RR_PERPH_RESET_CTL2 (at 0x45d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_ADC_RR_PERPH_RESET_CTL3"
      sgroup "FG_ADC_RR_PERPH_RESET_CTL3 (at 0x45da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_ADC_RR_PERPH_RESET_CTL4"
      sgroup "FG_ADC_RR_PERPH_RESET_CTL4 (at 0x45db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_ADC_RR_INT_TEST1"
      sgroup "FG_ADC_RR_INT_TEST1 (at 0x45e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_ADC_RR_INT_TEST_VAL"
      sgroup "FG_ADC_RR_INT_TEST_VAL (at 0x45e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_SPARE                                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RR_BUS_ERR                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RR                                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BT_ID                                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "FG_ADC_RR_TM_TRIGGER_CTRLS"
      sgroup "FG_ADC_RR_TM_TRIGGER_CTRLS (at 0x45e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RR_CONV_TRIGGER                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RR_CONV_CTRL                             = " "0 (LOGIC),1 (REGISTER)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RR_GOC_BYPASS                            = " "0 (LOG_RR_DT),1 (LOG_RRGOC_DT),2 (LOG_RRADC_DT),3 (reserved)"
    tree.end
    tree "FG_ADC_RR_TM_ADC_CTRLS"
      sgroup "FG_ADC_RR_TM_ADC_CTRLS (at 0x45e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_CONVERSION                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RR_ADC_CTRL                              = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_TM_CNL_CTRL"
      sgroup "FG_ADC_RR_TM_CNL_CTRL (at 0x45e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RR_ADC_CTRL                              = "
    tree.end
    tree "FG_ADC_RR_TM_BATT_ID_CTRL"
      sgroup "FG_ADC_RR_TM_BATT_ID_CTRL (at 0x45e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_BATT_ID_BIAS                       = " "0 (BIASNONE),1 (BIAS5UA),2 (BIAS15UA),3 (BIAS150UA)"
    tree.end
    tree "FG_ADC_RR_TM_THERM_CTRL"
      sgroup "FG_ADC_RR_TM_THERM_CTRL (at 0x45e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AUX_RBIAS_CTRL_OFF                       = " "0 (BIAS_VOLTAGE_ENABLED),1 (BIAS_VOLTAFE_DISABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_RBIAS_CTRL_OFF                      = " "0 (BIAS_VOLTAGE_ENABLED),1 (BIAS_VOLTAFE_DISABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AUX_THERM_RBIAS_CTRL                     = " "0 (RBIAS_UNFORCE),1 (RBIAS_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_THERM_RBIAS_CTRL                    = " "0 (RBIAS_UNFORCE),1 (RBIAS_FORCED_ON)"
    tree.end
    tree "FG_ADC_RR_TM_CONV_STS"
      sgroup "FG_ADC_RR_TM_CONV_STS (at 0x45e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_CONV_STS                             = " "0 (ADC_DONE),1 (ADC_NOT_DONE)"
    tree.end
    tree "FG_ADC_RR_TM_ADC_READ_LSB"
      sgroup "FG_ADC_RR_TM_ADC_READ_LSB (at 0x45e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_ADC_RR_TM_ADC_READ_MSB"
      sgroup "FG_ADC_RR_TM_ADC_READ_MSB (at 0x45e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VALUE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_ADC_RR_TM_ATEST_MUX_1"
      sgroup "FG_ADC_RR_TM_ATEST_MUX_1 (at 0x45ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MUX_EN_CTRL                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MUX_SEL                                  = "
    tree.end
    tree "FG_ADC_RR_TM_ATEST_MUX_2"
      sgroup "FG_ADC_RR_TM_ATEST_MUX_2 (at 0x45eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MUX_EN_CTRL                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MUX_SEL                                  = "
    tree.end
    tree "FG_ADC_RR_TM_REFERENCES"
      sgroup "FG_ADC_RR_TM_REFERENCES (at 0x45ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   RR_REF_BUF_FORCE_CTRL                    = " "0 (DO_NOT_FORCE),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RR_REF_BUF_REG_CTRL                      = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BG_BUFFER_CTRL                           = " "0 (DO_NOT_FORCE),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BG_CTRL                                  = " "0 (DO_NOT_FORCE),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LDO_CONTROL_CTRL                         = " "0 (DO_NOT_FORCE),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   REF_LOGIC_REG_CTRL                       = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_TM_MISC_CTL"
      sgroup "FG_ADC_RR_TM_MISC_CTL (at 0x45ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_CHARGER_TEMP_REQ                   = " "0 (NORMAL),1 (FORCE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_PMI_DIE_TEMP_REQ                   = " "0 (NORMAL),1 (FORCE)"
    tree.end
    tree "FG_ADC_RR_TM_RR_CTRL"
      sgroup "FG_ADC_RR_TM_RR_CTRL (at 0x45ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DC_IN_CONNECTED                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_IN_CONNECTED                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SWITCHER_USE_DCIN_FORCE_CTRL             = " "0 (DCIN_NOT_IN_USE),1 (DCIN_IN_USE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SWITCHER_USE_USBIN_FORCE_CTRL            = " "0 (USBIN_NOT_IN_USE),1 (USBIN_IN_USE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INPUT_CUR_MUX_REG_CTRL                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   REF_RNG_SEL_FORCE_CTRL                   = " "0 (REF_IS_RBIAS),1 (REF_IS_5_DIV_3_V),2 (REF_IS_5_DIV_2_V),3 (REF_IS_5_V)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   REF_RNG_SEL_REG_CTRL                     = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_ADC_RR_TRIM_NUM"
      sgroup "FG_ADC_RR_TRIM_NUM (at 0x45f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "FG_ADC_RR_THERM_GAIN"
      sgroup "FG_ADC_RR_THERM_GAIN (at 0x45f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_THERM_OFFSET"
      sgroup "FG_ADC_RR_THERM_OFFSET (at 0x45f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_DIG_5V_GAIN"
      sgroup "FG_ADC_RR_DIG_5V_GAIN (at 0x45f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_DIG_5V_OFFSET"
      sgroup "FG_ADC_RR_DIG_5V_OFFSET (at 0x45f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_USBIN_I_GAIN"
      sgroup "FG_ADC_RR_USBIN_I_GAIN (at 0x45f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_USBIN_I_OFFSET"
      sgroup "FG_ADC_RR_USBIN_I_OFFSET (at 0x45f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_DCIN_I_GAIN"
      sgroup "FG_ADC_RR_DCIN_I_GAIN (at 0x45f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_DCIN_I_OFFSET"
      sgroup "FG_ADC_RR_DCIN_I_OFFSET (at 0x45f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_DIG_2P5_V_GAIN"
      sgroup "FG_ADC_RR_DIG_2P5_V_GAIN (at 0x45f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_DIG_2P5_V_OFFSET"
      sgroup "FG_ADC_RR_DIG_2P5_V_OFFSET (at 0x45fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_TMP_GAIN"
      sgroup "FG_ADC_RR_TMP_GAIN (at 0x45fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_TMP_OFFSET"
      sgroup "FG_ADC_RR_TMP_OFFSET (at 0x45fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_VAL                                 = "
    tree.end
    tree "FG_ADC_RR_MISC_TRIM"
      sgroup "FG_ADC_RR_MISC_TRIM (at 0x45fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   THERM_BIAS_TRIM                          = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "FG_BATT_INFO"
  tree "FG_BATT_INFO"
    tree "FG_BATT_INFO_PERPH_TYPE"
      sgroup "FG_BATT_INFO_PERPH_TYPE (at 0x4104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_BATT_INFO_PERPH_SUBTYPE"
      sgroup "FG_BATT_INFO_PERPH_SUBTYPE (at 0x4105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_BATT_INFO_BATTERY_TEMP_STS"
      sgroup "FG_BATT_INFO_BATTERY_TEMP_STS (at 0x4106)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   JEITA_TOO_HOT_STS                        = " "0 (BATT_TEMP_BELOW),1 (BATT_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   JEITA_HOT_STS                            = " "0 (BATT_TEMP_BELOW),1 (BATT_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   JEITA_COLD_STS                           = " "0 (BATT_TEMP_BELOW),1 (BATT_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   JEITA_TOO_COLD_STS                       = " "0 (BATT_TEMP_BELOW),1 (BATT_TEMP_ABOVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BATT_TEMP_DELTA                          = " "0 (NORMAL),1 (TEMP_CHANGED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_TEMP_AVAILABILITY                   = " "0 (NOT_READY),1 (READY)"
    tree.end
    tree "FG_BATT_INFO_SYS_BATT"
      sgroup "FG_BATT_INFO_SYS_BATT (at 0x4107)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_REMOVED_LATCHED_STS                 = " "0 (BATT_PRESENT),1 (BATT_REMOVED_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_MISSING_HW                          = " "0 (BATT_IS_PRESENT),1 (BATT_MISSING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BATT_MISSING_ALG                         = " "0 (BATT_IS_PRESENT),1 (BATT_MISSING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_MISSING_CMP                         = " "0 (BATT_IS_PRESENT),1 (BATT_MISSING)"
    tree.end
    tree "FG_BATT_INFO_FG_STS"
      sgroup "FG_BATT_INFO_FG_STS (at 0x4109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_WD_RESET                              = " "0 (NO_RESETS),1 (WD_CAUSED_FG_RESET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_CRG_TRM                               = " "0 (CRG_STATUS_QUO),1 (CRG_TERMINATE)"
    tree.end
    tree "FG_BATT_INFO_INT_RT_STS"
      sgroup "FG_BATT_INFO_INT_RT_STS (at 0x4110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_BATT_INFO_INT_SET_TYPE"
      sgroup "FG_BATT_INFO_INT_SET_TYPE (at 0x4111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_BATT_INFO_INT_POLARITY_HIGH"
      sgroup "FG_BATT_INFO_INT_POLARITY_HIGH (at 0x4112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_INFO_INT_POLARITY_LOW"
      sgroup "FG_BATT_INFO_INT_POLARITY_LOW (at 0x4113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_INFO_INT_LATCHED_CLR"
      sgroup "FG_BATT_INFO_INT_LATCHED_CLR (at 0x4114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_BATT_INFO_INT_EN_SET"
      sgroup "FG_BATT_INFO_INT_EN_SET (at 0x4115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
    tree.end
    tree "FG_BATT_INFO_INT_EN_CLR"
      sgroup "FG_BATT_INFO_INT_EN_CLR (at 0x4116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
    tree.end
    tree "FG_BATT_INFO_INT_LATCHED_STS"
      sgroup "FG_BATT_INFO_INT_LATCHED_STS (at 0x4118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
    tree.end
    tree "FG_BATT_INFO_INT_PENDING_STS"
      sgroup "FG_BATT_INFO_INT_PENDING_STS (at 0x4119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
    tree.end
    tree "FG_BATT_INFO_INT_MID_SEL"
      sgroup "FG_BATT_INFO_INT_MID_SEL (at 0x411a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_BATT_INFO_INT_PRIORITY"
      sgroup "FG_BATT_INFO_INT_PRIORITY (at 0x411b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY0),1 (INT_PRIORITY1)"
    tree.end
    tree "FG_BATT_INFO_SMART_BATTERY"
      sgroup "FG_BATT_INFO_SMART_BATTERY (at 0x4148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BSI_SMART_BATTERY                        = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_BATT_REMOVED_LATCHED"
      sgroup "FG_BATT_INFO_BATT_REMOVED_LATCHED (at 0x414f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80414f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x414f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLR                                      = " "0 (BATT_REMOVED_LATCH_CLEAR_FALSE),1 (BATT_REMOVED_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_BATT_INFO_BATTERY_TEMPERATURE_LSB"
      sgroup "FG_BATT_INFO_BATTERY_TEMPERATURE_LSB (at 0x4150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_BATTERY_TEMPERATURE_MSB"
      sgroup "FG_BATT_INFO_BATTERY_TEMPERATURE_MSB (at 0x4151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VALUE                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_BATT_INFO_BATTERY_TEMP_CFG"
      sgroup "FG_BATT_INFO_BATTERY_TEMP_CFG (at 0x4156)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   JEITA_TEMP_HYST                          = " "0 (NO_HYSTERESIS),1 (HYST_1_C),2 (HYST_2_C),3 (HYST_3_C)"
    tree.end
    tree "FG_BATT_INFO_BATT_TMPR_INTR"
      sgroup "FG_BATT_INFO_BATT_TMPR_INTR (at 0x4159)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHANGE_THRESHOLD                         = " "0 (BTEMP_DELTA_2K),1 (BTEMP_DELTA_4K),2 (BTEMP_DELTA_6K),3 (BTEMP_DELTA_10K)"
    tree.end
    tree "FG_BATT_INFO_THERM_THERM_C1"
      sgroup "FG_BATT_INFO_THERM_THERM_C1 (at 0x415c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80415c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x415c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COEFF_VALUE                              = "
    tree.end
    tree "FG_BATT_INFO_THERM_THERM_C2"
      sgroup "FG_BATT_INFO_THERM_THERM_C2 (at 0x415d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80415d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x415d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COEFF_VALUE                              = "
    tree.end
    tree "FG_BATT_INFO_THERM_THERM_C3"
      sgroup "FG_BATT_INFO_THERM_THERM_C3 (at 0x415e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80415e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x415e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COEFF_VALUE                              = "
    tree.end
    tree "FG_BATT_INFO_THERM_THERM_HALF_RANGE"
      sgroup "FG_BATT_INFO_THERM_THERM_HALF_RANGE (at 0x415f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80415f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x415f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEMP_VALUE                               = "
    tree.end
    tree "FG_BATT_INFO_JEITA_CTLS"
      sgroup "FG_BATT_INFO_JEITA_CTLS (at 0x4161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_STS_CLEAR                          = " "0 (DO_NOT_CLEAR),1 (CLEAR)"
    tree.end
    tree "FG_BATT_INFO_JEITA_TOO_COLD"
      sgroup "FG_BATT_INFO_JEITA_TOO_COLD (at 0x4162)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_BATT_INFO_JEITA_COLD"
      sgroup "FG_BATT_INFO_JEITA_COLD (at 0x4163)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_BATT_INFO_JEITA_HOT"
      sgroup "FG_BATT_INFO_JEITA_HOT (at 0x4164)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_BATT_INFO_JEITA_TOO_HOT"
      sgroup "FG_BATT_INFO_JEITA_TOO_HOT (at 0x4165)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRESHOLD                                = "
    tree.end
    tree "FG_BATT_INFO_ESR_GENERAL_CFG"
      sgroup "FG_BATT_INFO_ESR_GENERAL_CFG (at 0x4168)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ESR_DEEP_TAPER_EN                        = " "0 (ESR_DEEP_TAPER_DISABLE),1 (ESR_DEEP_TAPER_ENABLE)"
    tree.end
    tree "FG_BATT_INFO_ESR_PULL_DOWN_CFG"
      sgroup "FG_BATT_INFO_ESR_PULL_DOWN_CFG (at 0x4169)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ESR_PULL_DOWN_IVAL                       = " "0 (ESR_MEAS_CUR_60MA),1 (ESR_MEAS_CUR_180MA),2 (ESR_MEAS_CUR_120MA),3 (ESR_MEAS_CUR_240MA)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ESR_PULL_DOWN_MODE                       = " "0 (NO_PULL_DOWN),1 (STATIC_PULL_DOWN),2 (CRG_DSC_PULL_DOWN),3 (DSC_PULL_DOWN)"
    tree.end
    tree "FG_BATT_INFO_ESR_FAST_CRG_CFG"
      sgroup "FG_BATT_INFO_ESR_FAST_CRG_CFG (at 0x416a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80416a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x416a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   ESR_FAST_CRG_IVAL                        = " "0 (FCC300MA),1 (FCC600MA),2 (FCC1A),3 (FCC2A),4 (FCC3A),5 (FCC4A),6 (FCC5A),7 (FCC6A)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ESR_FAST_CRG_CTL_EN                      = " "0, 1"
    tree.end
    tree "FG_BATT_INFO_BATTERY_MISSING_CFG"
      sgroup "FG_BATT_INFO_BATTERY_MISSING_CFG (at 0x416b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80416b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x416b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   BM_THERM_TH                              = " "0 (RES_TH_0P75_MOHM),1 (RES_TH_1P00_MOHM),2 (RES_TH_1P50_MOHM),3 (RES_TH_3P00_MOHM)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BM_BATT_ID_TH                            = " "0 (TBD_1),1 (TBD_2),2 (TBD_3),3 (TBD_4)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BM_FROM_THERM                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BM_FROM_BATT_ID                          = " "0, 1"
    tree.end
    tree "FG_BATT_INFO_WATCHDOG_COUNT"
      sgroup "FG_BATT_INFO_WATCHDOG_COUNT (at 0x4170)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_WATCHDOG_CFG"
      sgroup "FG_BATT_INFO_WATCHDOG_CFG (at 0x4171)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RESET_CAPABLE                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PET_CTRL                                 = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_CTRL                              = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_IBATT_SENSING_CFG"
      sgroup "FG_BATT_INFO_IBATT_SENSING_CFG (at 0x4173)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ADC_BITSTREAM_INV                        = " "0 (DO_NOT_INVERT),1 (INVERT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SOURCE_SELECT                            = " "0 (BATFET),1 (SENSERESISTOR),2 (BATFET_W_SMB),3 (RESERVED)"
    tree.end
    tree "FG_BATT_INFO_QNOVO_CFG"
      sgroup "FG_BATT_INFO_QNOVO_CFG (at 0x4174)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LD_REG_FORCE_CTRL                        = " "0 (FORCE_LOW),1 (FORCE_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LD_REG_CTRL                              = " "0 (LOGIC_CONTROL),1 (REG_CONTROL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BIT_STREAM_CFG                           = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_QNOVO_SCALER"
      sgroup "FG_BATT_INFO_QNOVO_SCALER (at 0x4175)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_CRG_SERVICES"
      sgroup "FG_BATT_INFO_CRG_SERVICES (at 0x4190)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_CRG_TRM_EN                            = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_VBATT_LSB"
      sgroup "FG_BATT_INFO_VBATT_LSB (at 0x41a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_VBATT_MSB"
      sgroup "FG_BATT_INFO_VBATT_MSB (at 0x41a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_IBATT_LSB"
      sgroup "FG_BATT_INFO_IBATT_LSB (at 0x41a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_IBATT_MSB"
      sgroup "FG_BATT_INFO_IBATT_MSB (at 0x41a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_ESR_LSB"
      sgroup "FG_BATT_INFO_ESR_LSB (at 0x41a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_ESR_MSB"
      sgroup "FG_BATT_INFO_ESR_MSB (at 0x41a5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_VBATT_LSB_CP"
      sgroup "FG_BATT_INFO_VBATT_LSB_CP (at 0x41a6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_VBATT_MSB_CP"
      sgroup "FG_BATT_INFO_VBATT_MSB_CP (at 0x41a7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_IBATT_LSB_CP"
      sgroup "FG_BATT_INFO_IBATT_LSB_CP (at 0x41a8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_IBATT_MSB_CP"
      sgroup "FG_BATT_INFO_IBATT_MSB_CP (at 0x41a9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_ESR_LSB_CP"
      sgroup "FG_BATT_INFO_ESR_LSB_CP (at 0x41aa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_ESR_MSB_CP"
      sgroup "FG_BATT_INFO_ESR_MSB_CP (at 0x41ab)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_BATT_VADC_LSB"
      sgroup "FG_BATT_INFO_BATT_VADC_LSB (at 0x41ac)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_BATT_VADC_MSB"
      sgroup "FG_BATT_INFO_BATT_VADC_MSB (at 0x41ad)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ad0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_BATT_IADC_LSB"
      sgroup "FG_BATT_INFO_BATT_IADC_LSB (at 0x41ae)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ae0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ae0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_BATT_IADC_MSB"
      sgroup "FG_BATT_INFO_BATT_IADC_MSB (at 0x41af)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041af0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41af0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VALUE                                    = "
    tree.end
    tree "FG_BATT_INFO_SEC_ACCESS"
      sgroup "FG_BATT_INFO_SEC_ACCESS (at 0x41d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_BATT_INFO_PERPH_RESET_CTL2"
      sgroup "FG_BATT_INFO_PERPH_RESET_CTL2 (at 0x41d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_BATT_INFO_PERPH_RESET_CTL3"
      sgroup "FG_BATT_INFO_PERPH_RESET_CTL3 (at 0x41da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_BATT_INFO_PERPH_RESET_CTL4"
      sgroup "FG_BATT_INFO_PERPH_RESET_CTL4 (at 0x41db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "FG_BATT_INFO_INT_TEST1"
      sgroup "FG_BATT_INFO_INT_TEST1 (at 0x41e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLE),1 (INT_TEST_MODE_ENABLE)"
    tree.end
    tree "FG_BATT_INFO_INT_TEST_VAL"
      sgroup "FG_BATT_INFO_INT_TEST_VAL (at 0x41e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BT_TMPR_DELTA                            = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_EXP                                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BT_ATTN                                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BT_MISS                                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ESR_DELTA                                = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBT_LOW                                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBT_PRD_DELTA                            = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "FG_BATT_INFO_TM_BSI"
      sgroup "FG_BATT_INFO_TM_BSI (at 0x41e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BSI_DISABLE                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BSI_REG_CTRL                             = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSI_IN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BSI_OUT                                  = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BSI_RPU                                  = " "0, 1"
    tree.end
    tree "FG_BATT_INFO_TM_BATTERY_MISSING"
      sgroup "FG_BATT_INFO_TM_BATTERY_MISSING (at 0x41e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CMP_BM_FORCE_SET                         = " "0 (BATTERY_PRESENT),1 (BATTERY_MISSING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CMP_BM_REG_CTRL                          = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FG_BM_FORCE_SET                          = " "0 (BATTERY_PRESENT),1 (BATTERY_MISSING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FG_BM_REG_CTRL                           = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_TM_READBACK"
      sgroup "FG_BATT_INFO_TM_READBACK (at 0x41e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATT_VADC_DONE                           = " "0 (CONV_RESULT_NOT_READY),1 (CONV_RESULT_READY)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_IADC_DONE                           = " "0 (CONV_RESULT_NOT_READY),1 (CONV_RESULT_READY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BM_THERM_CMP_OUT                         = " "0 (BATT_IS_PRESENT),1 (BATT_MISSING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BM_BATT_ID_CMP_OUT                       = " "0 (BATT_IS_PRESENT),1 (BATT_MISSING)"
    tree.end
    tree "FG_BATT_INFO_TM_MISC0"
      sgroup "FG_BATT_INFO_TM_MISC0 (at 0x41e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_SEQ_RESP_TOGGLE                    = " "0 (DO_NOT_FORCE),1 (FORCE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ALG_DIRECT_VALID_DATA                    = " "0 (INVALID),1 (VALID)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALG_DIRECT_MODE_EN                       = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATT_VADC_CONV                           = " "0 (CONVERSION_NOT_REQUESTED),1 (CONVERSION_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_IADC_CONV                           = " "0 (CONVERSION_NOT_REQUESTED),1 (CONVERSION_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADC_ENABLE_REG_DRIVEN                    = " "0 (USE_LOGIC),1 (ENABLE_REGISTER_CTRL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_FORCE_EXP                       = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_TM_MISC1"
      sgroup "FG_BATT_INFO_TM_MISC1 (at 0x41e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ESR_REQ_CTL                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ESR_REQ_CTL_EN                           = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_FG_PBS_TRIG"
      sgroup "FG_BATT_INFO_FG_PBS_TRIG (at 0x41e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_SEL_EN                             = " "0 (ENABLE_DTEST_FOR_PBS_DISABLE),1 (ENABLE_DTEST_FOR_PBS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   INV                                      = " "0 (INVERT_DTEST_DISABLE),1 (INVERT_DTEST_ENABLE)"
    tree.end
    tree "FG_BATT_INFO_FG_PBS_TRIG_STS"
      sgroup "FG_BATT_INFO_FG_PBS_TRIG_STS (at 0x41e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PBS_TRIG_STS                             = " "0 (LOW),1 (HIGH)"
    tree.end
    tree "FG_BATT_INFO_PEEK_MUX_EN"
      sgroup "FG_BATT_INFO_PEEK_MUX_EN (at 0x41ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PEEK_MUX_4_CTL                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PEEK_MUX_3_CTL                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PEEK_MUX_2_CTL                           = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PEEK_MUX_1_CTL                           = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_INFO_PEEK_MUX1"
      sgroup "FG_BATT_INFO_PEEK_MUX1 (at 0x41eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_INFO_PEEK_MUX2"
      sgroup "FG_BATT_INFO_PEEK_MUX2 (at 0x41ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_INFO_PEEK_MUX3"
      sgroup "FG_BATT_INFO_PEEK_MUX3 (at 0x41ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_INFO_PEEK_MUX4"
      sgroup "FG_BATT_INFO_PEEK_MUX4 (at 0x41ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST_SEL                                = "
    tree.end
    tree "FG_BATT_INFO_RDBACK"
      sgroup "FG_BATT_INFO_RDBACK (at 0x41ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PEEK_MUX                                 = "
    tree.end
    tree "FG_BATT_INFO_TRIM_NUM"
      sgroup "FG_BATT_INFO_TRIM_NUM (at 0x41f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_NUM                                 = "
    tree.end
    tree "FG_BATT_INFO_BATT_ID_CURR0"
      sgroup "FG_BATT_INFO_BATT_ID_CURR0 (at 0x41f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   TRIM_150_UA                              = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIM_15_UA                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "FG_BATT_INFO_BATT_ID_CURR1"
      sgroup "FG_BATT_INFO_BATT_ID_CURR1 (at 0x41f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIM_5_UA                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "FG_BATT_SOC"
  tree "FG_BATT_SOC"
    tree "FG_BATT_SOC_PERPH_TYPE"
      sgroup "FG_BATT_SOC_PERPH_TYPE (at 0x4004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_BATT_SOC_PERPH_SUBTYPE"
      sgroup "FG_BATT_SOC_PERPH_SUBTYPE (at 0x4005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_BATT_SOC_FG_ALG_STS"
      sgroup "FG_BATT_SOC_FG_ALG_STS (at 0x4006)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RDY                                      = " "0 (FG_NOT_READY),1 (FG_READY)"
    tree.end
    tree "FG_BATT_SOC_FG_ALG_AUX_STS0"
      sgroup "FG_BATT_SOC_FG_ALG_AUX_STS0 (at 0x4007)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_BELOW_TERMINATION0                     = " "0 (TERM_CURRENT_NOT_REACHED),1 (TERM_CURRENT_REACHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   I_BELOW_TERMINATION1                     = " "0 (TERM_CURRENT_NOT_REACHED),1 (TERM_CURRENT_REACHED)"
    tree.end
    tree "FG_BATT_SOC_SLEEP_SHUTDOWN_STS"
      sgroup "FG_BATT_SOC_SLEEP_SHUTDOWN_STS (at 0x4008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SLEEP_SYNC                               = " "0 (NOT_IN_SYNC_SLEEP),1 (IN_SYNC_SLEEP)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ESR_QUEUED                               = " "0 (ESR_NOT_QUEUED),1 (ESR_QUEUED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SYNC_SLEEP_IBATT_QUAL                    = " "0 (IBATT_ABOVE_TH),1 (IBATT_BELOW_TH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FG_SHUTDOWN_ALLOWED                      = " "0 (FG_NOT_IN_SHDN),1 (FG_SHDN_ACK)"
    tree.end
    tree "FG_BATT_SOC_FG_MONOTONIC_SOC"
      sgroup "FG_BATT_SOC_FG_MONOTONIC_SOC (at 0x4009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BATT_SOC_FG_MONOTONIC_SOC_CP"
      sgroup "FG_BATT_SOC_FG_MONOTONIC_SOC_CP (at 0x400a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BATT_SOC_INT_RT_STS"
      sgroup "FG_BATT_SOC_INT_RT_STS (at 0x4010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_BATT_SOC_INT_SET_TYPE"
      sgroup "FG_BATT_SOC_INT_SET_TYPE (at 0x4011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_BATT_SOC_INT_POLARITY_HIGH"
      sgroup "FG_BATT_SOC_INT_POLARITY_HIGH (at 0x4012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_SOC_INT_POLARITY_LOW"
      sgroup "FG_BATT_SOC_INT_POLARITY_LOW (at 0x4013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BATT_SOC_INT_LATCHED_CLR"
      sgroup "FG_BATT_SOC_INT_LATCHED_CLR (at 0x4014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_BATT_SOC_INT_EN_SET"
      sgroup "FG_BATT_SOC_INT_EN_SET (at 0x4015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_BATT_SOC_INT_EN_CLR"
      sgroup "FG_BATT_SOC_INT_EN_CLR (at 0x4016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_BATT_SOC_INT_LATCHED_STS"
      sgroup "FG_BATT_SOC_INT_LATCHED_STS (at 0x4018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_BATT_SOC_INT_PENDING_STS"
      sgroup "FG_BATT_SOC_INT_PENDING_STS (at 0x4019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_BATT_SOC_INT_MID_SEL"
      sgroup "FG_BATT_SOC_INT_MID_SEL (at 0x401a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_BATT_SOC_INT_PRIORITY"
      sgroup "FG_BATT_SOC_INT_PRIORITY (at 0x401b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_BATT_SOC_EN_CTL"
      sgroup "FG_BATT_SOC_EN_CTL (at 0x4046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FG_ALGORITHM_EN                          = " "0 (FG_IN_SHUTDOWN),1 (FG_ACTIVE)"
    tree.end
    tree "FG_BATT_SOC_RESTART"
      sgroup "FG_BATT_SOC_RESTART (at 0x4048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GO                                       = " "0 (DO_NOT_EXECUTE_SEQUENCE),1 (EXECUTE_SEQUENCE)"
    tree.end
    tree "FG_BATT_SOC_STS_CLR"
      sgroup "FG_BATT_SOC_STS_CLR (at 0x404a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SEQ_ERROR_CLEAR                          = " "0 (NORMAL),1 (CLEAR)"
    tree.end
    tree "FG_BATT_SOC_LOW_PWR_CFG"
      sgroup "FG_BATT_SOC_LOW_PWR_CFG (at 0x4052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SYNC_SLEEP_EN                            = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SYNC_SLEEP_CFG                           = " "0 (ACTIVE2_SLEEP2),1 (ACTIVE2_SLEEP4),2 (ACTIVE2_SLEEP8),3 (ACTIVE2_SLEEP14)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYNC_SLEEP_REGEN_ESR_EN                  = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SYNC_SLEEP_THRSH2_EN                     = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BATT_SOC_LOW_PWR_STS"
      sgroup "FG_BATT_SOC_LOW_PWR_STS (at 0x4056)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SYNC_COUNTER                             = "
    tree.end
    tree "FG_BATT_SOC_COMPUTE_TRACK_STS"
      sgroup "FG_BATT_SOC_COMPUTE_TRACK_STS (at 0x40b6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STATE                                    = "
    tree.end
    tree "FG_BATT_SOC_DEBUG_STS"
      sgroup "FG_BATT_SOC_DEBUG_STS (at 0x40b7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ACLKRQ                                   = " "0 (ALG_CLK_NOT_REQUESTED),1 (ALG_CLK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SQRQMLTERR                               = " "0 (SEQ_REQ_NO_ERROR),1 (SEQ_REQ_ERROR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SQRSPACPTERR                             = " "0 (SEQ_RSP_NO_ERROR),1 (SEQ_RSP_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TMPRABSERR                               = " "0 (TEMPERATURE_REQ_NO_ERROR),1 (TEMPERATURE_REQ_ERROR)"
    tree.end
    tree "FG_BATT_SOC_FG_CYA_CFG"
      sgroup "FG_BATT_SOC_FG_CYA_CFG (at 0x40b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   V_ADC_CMP_POL_TRIM                       = " "0 (V_ADC_POS_IS_POS),1 (V_ADC_POS_IS_NEG)"
    tree.end
    tree "FG_BATT_SOC_RST_CTRL0"
      sgroup "FG_BATT_SOC_RST_CTRL0 (at 0x40ba)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BCL_RST                                  = " "0 (OUT_OF_RESET),1 (IN_RESET)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_RST                                  = " "0 (OUT_OF_RESET),1 (IN_RESET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALG_RST                                  = " "0 (OUT_OF_RESET),1 (IN_RESET)"
    tree.end
    tree "FG_BATT_SOC_RST_CTRL1"
      sgroup "FG_BATT_SOC_RST_CTRL1 (at 0x40bb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040bb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40bb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DVD_RST                                  = " "0 (OUT_OF_RESET),1 (IN_RESET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPN_RST                                  = " "0 (OUT_OF_RESET),1 (IN_RESET)"
    tree.end
    tree "FG_BATT_SOC_SEC_ACCESS"
      sgroup "FG_BATT_SOC_SEC_ACCESS (at 0x40d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_BATT_SOC_PERPH_RESET_CTL2"
      sgroup "FG_BATT_SOC_PERPH_RESET_CTL2 (at 0x40d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_BATT_SOC_PERPH_RESET_CTL3"
      sgroup "FG_BATT_SOC_PERPH_RESET_CTL3 (at 0x40da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_BATT_SOC_PERPH_RESET_CTL4"
      sgroup "FG_BATT_SOC_PERPH_RESET_CTL4 (at 0x40db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_BATT_SOC_INT_TEST1"
      sgroup "FG_BATT_SOC_INT_TEST1 (at 0x40e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_BATT_SOC_INT_TEST_VAL"
      sgroup "FG_BATT_SOC_INT_TEST_VAL (at 0x40e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MSOC_FULL                                = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MSOC_HIGH                                = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MSOC_EMPTY                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MSOC_LOW                                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MSOC_DELTA                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BSOC_DELTA                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SOC_READY                                = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOC_UPDT                                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "FG_BATT_SOC_TEST_MUX0"
      sgroup "FG_BATT_SOC_TEST_MUX0 (at 0x40eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_SYS_SLEEP                          = " "0 (FORCE0),1 (FORCE1)"
    tree.end
    tree "FG_BATT_SOC_TM_ALTCLK_CTRL"
      sgroup "FG_BATT_SOC_TM_ALTCLK_CTRL (at 0x40ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BCL_CLK_SLCT                             = " "0 (BCLK_200KHZ),1 (BCLK_DTEST3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ALGIMA_CLK_SLCT                          = " "0 (AICLK_4P8MHZ),1 (AICLK_RESERVED),2 (AICLK_200KHZ),3 (AICLK_DTEST3)"
    tree.end
    tree "FG_BATT_SOC_TM_CLK_CTRL"
      sgroup "FG_BATT_SOC_TM_CLK_CTRL (at 0x40ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BCL_CLK_FORCE                            = " "0 (DO_NOT_FORCE_ENABLE),1 (FORCE_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_CLK_REQ_CTRL                         = " "0 (LOGIC_CONTROL),1 (REGISTER_CONTROL)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IMA_CLK_FORCE                            = " "0 (DO_NOT_FORCE_ENABLE),1 (FORCE_ENABLE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IMA_CLK_REQ_CTRL                         = " "0 (LOGIC_CONTROL),1 (REGISTER_CONTROL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ALG_CLK_FORCE                            = " "0 (DO_NOT_FORCE_ENABLE),1 (FORCE_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALG_CLK_REQ_CTRL                         = " "0 (LOGIC_CONTROL),1 (REGISTER_CONTROL)"
    tree.end
    tree "FG_BATT_SOC_TRIM_NUM"
      sgroup "FG_BATT_SOC_TRIM_NUM (at 0x40f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_NUM                                 = "
    tree.end
  tree.end
tree.end
tree "FG_BCL"
  tree "FG_BCL"
    tree "FG_BCL_PERPH_TYPE"
      sgroup "FG_BCL_PERPH_TYPE (at 0x4204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_BCL_PERPH_SUBTYPE"
      sgroup "FG_BCL_PERPH_SUBTYPE (at 0x4205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_BCL_BCL_MONITOR_STS"
      sgroup "FG_BCL_BCL_MONITOR_STS (at 0x4206)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VBATT_CMP_SMPL_RDY                       = " "0 (NOT_READY),1 (READY)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VBATT_CMP_STS                            = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BCNV0DN                                  = " "0 (DATA_NOT_AVAILABLE),1 (DATA_AVAILABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BSHUTDWNACK                              = " "0 (BCL_SHND_NOT_ACK),1 (BCL_SHND_ACK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BDTAVAIL                                 = " "0 (DATA_NOT_AVAILABLE),1 (DATA_AVAILABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BCL_MODE_FROM_FG                         = " "0 (BCL_IS_LPM),1 (BCL_IS_HPM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BCL_MODE                                 = " "0 (BCL_IS_LPM),1 (BCL_IS_HPM)"
    tree.end
    tree "FG_BCL_BATT_VI_MONITOR"
      sgroup "FG_BCL_BATT_VI_MONITOR (at 0x4207)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VBATT_ADC_LOW                            = " "0 (VBAT_BELOW_TH),1 (VBAT_ABOVE_TH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VBATT_TOO_LOW_FLT                        = " "0 (VBAT_BELOW_TH),1 (VBAT_ABOVE_TH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBATT_TOO_LOW_RAW                        = " "0 (VBAT_BELOW_TH),1 (VBAT_ABOVE_TH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBATT_LOW_FLT                            = " "0 (VBAT_BELOW_TH),1 (VBAT_ABOVE_TH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBATT_LOW_RAW                            = " "0 (VBAT_BELOW_TH),1 (VBAT_ABOVE_TH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBATT_TOO_HIGH                           = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBATT_HIGH                               = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_LMH_STS0"
      sgroup "FG_BCL_LMH_STS0 (at 0x4208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LMH_LEVEL_2                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LMH_LEVEL_1                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LEVEL_0                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_SYSOK                                = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_OFF                                  = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_LMH_STS1"
      sgroup "FG_BCL_LMH_STS1 (at 0x4209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LMH_BAN_CRG                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_BAN_FLASH                            = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_BAN_WIL                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_BAN_PBS                              = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_BAN_STS"
      sgroup "FG_BCL_BAN_STS (at 0x420a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80420a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x420a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAN_SRC_VBATT_TL                         = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAN_SRC_IBATT_TH                         = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAN_PIN_STS                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM                               = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_BATFET_OPEN_STS"
      sgroup "FG_BCL_BATFET_OPEN_STS (at 0x420b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80420b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x420b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BTF_OPEN_SRC_VBATT                       = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BTF_OPEN_SRC_IBATT                       = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BTF_OPEN_ACK_CRG                         = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BTF_OPEN_PBS                             = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BTF_OPEN                                 = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BTF_OPEN_RAW                             = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_INT_RT_STS"
      sgroup "FG_BCL_INT_RT_STS (at 0x4210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_BCL_INT_SET_TYPE"
      sgroup "FG_BCL_INT_SET_TYPE (at 0x4211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_BCL_INT_POLARITY_HIGH"
      sgroup "FG_BCL_INT_POLARITY_HIGH (at 0x4212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BCL_INT_POLARITY_LOW"
      sgroup "FG_BCL_INT_POLARITY_LOW (at 0x4213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_BCL_INT_LATCHED_CLR"
      sgroup "FG_BCL_INT_LATCHED_CLR (at 0x4214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0, 1"
    tree.end
    tree "FG_BCL_INT_EN_SET"
      sgroup "FG_BCL_INT_EN_SET (at 0x4215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_BCL_INT_EN_CLR"
      sgroup "FG_BCL_INT_EN_CLR (at 0x4216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_BCL_INT_LATCHED_STS"
      sgroup "FG_BCL_INT_LATCHED_STS (at 0x4218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_BCL_INT_PENDING_STS"
      sgroup "FG_BCL_INT_PENDING_STS (at 0x4219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_BCL_INT_MID_SEL"
      sgroup "FG_BCL_INT_MID_SEL (at 0x421a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_BCL_INT_PRIORITY"
      sgroup "FG_BCL_INT_PRIORITY (at 0x421b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_BCL_EN_CTL"
      sgroup "FG_BCL_EN_CTL (at 0x4246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BCLEN                                    = " "0 (BCL_MONITORING_DISABLE),1 (BCL_MONITORING_ENABLE)"
    tree.end
    tree "FG_BCL_CLEAR_CTLS"
      sgroup "FG_BCL_CLEAR_CTLS (at 0x4248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BTALRMLOGCLR                             = " "0 (DO_NOT_CLEAR_LOG),1 (CLEAR_LOG)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBAT_MAX_CLEAR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBAT_MIN_CLEAR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BCLRALLX                                 = " "0 (PRESERVE_ALL_TIMER),1 (CLEAR_ALL_TIMERS)"
    tree.end
    tree "FG_BCL_IBATT_DGL_CTLS"
      sgroup "FG_BCL_IBATT_DGL_CTLS (at 0x424e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80424e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x424e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IB_TH_DRV_OUT                            = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IB_TH_CLRDX                              = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   IB_H_DRV_OUT                             = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IB_H_CLRDX                               = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_VBATT_ADC_DX_DGL_CTLS"
      sgroup "FG_BCL_VBATT_ADC_DX_DGL_CTLS (at 0x4250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DRV_OUT                                  = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLRDX                                    = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_VBATT_IRQ_DX_DGL_CTLS"
      sgroup "FG_BCL_VBATT_IRQ_DX_DGL_CTLS (at 0x4251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VB_TL_IRQ_DRV_OUT                        = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VB_TL_IRQ_CLRDX                          = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   VB_L_IRQ_DRV_OUT                         = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VB_L_IRQ_CLRDX                           = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_VBATT_CMP_AX_DGL_CTLS"
      sgroup "FG_BCL_VBATT_CMP_AX_DGL_CTLS (at 0x4252)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VB_TL_DRV_OUT                            = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VB_TL_CLRAX                              = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   VB_L_DRV_OUT                             = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VB_L_CLRAX                               = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_VBATT_CMP_DX_DGL_CTLS"
      sgroup "FG_BCL_VBATT_CMP_DX_DGL_CTLS (at 0x4253)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VB_TL_DRV_OUT                            = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VB_TL_CLRDX                              = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   VB_L_DRV_OUT                             = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VB_L_CLRDX                               = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_BAN_AX_DGL_CTLS"
      sgroup "FG_BCL_BAN_AX_DGL_CTLS (at 0x4255)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VB_TL_DRV_OUT                            = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VB_TL_CLRAX                              = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   IB_TH_DRV_OUT                            = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IB_TH_CLRAX                              = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_BAN_DX_DGL_CTLS"
      sgroup "FG_BCL_BAN_DX_DGL_CTLS (at 0x4256)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   BAN_DRV_OUT                              = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAN_CLRDX                                = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_BCL_SLEEP_DGL_CTLS"
      sgroup "FG_BCL_BCL_SLEEP_DGL_CTLS (at 0x4257)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DRV_OUT_DX                               = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CLRDX                                    = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DRV_OUT_AX                               = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLRAX                                    = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_VBATT"
      sgroup "FG_BCL_VBATT (at 0x4258)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_IBATT"
      sgroup "FG_BCL_IBATT (at 0x4259)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_VBAT_CP"
      sgroup "FG_BCL_VBAT_CP (at 0x425a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_IBAT_CP"
      sgroup "FG_BCL_IBAT_CP (at 0x425b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_VBAT_MIN"
      sgroup "FG_BCL_VBAT_MIN (at 0x425c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_IBAT_MAX"
      sgroup "FG_BCL_IBAT_MAX (at 0x425d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_VBAT_MIN_CP"
      sgroup "FG_BCL_VBAT_MIN_CP (at 0x425e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_IBAT_MAX_CP"
      sgroup "FG_BCL_IBAT_MAX_CP (at 0x425f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80425f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x425f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_IBAT_PARTIAL_0"
      sgroup "FG_BCL_IBAT_PARTIAL_0 (at 0x4260)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_IBAT_PARTIAL_1"
      sgroup "FG_BCL_IBAT_PARTIAL_1 (at 0x4261)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_IBAT_PARTIAL_0_CP"
      sgroup "FG_BCL_IBAT_PARTIAL_0_CP (at 0x4262)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_IBAT_PARTIAL_1_CP"
      sgroup "FG_BCL_IBAT_PARTIAL_1_CP (at 0x4263)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_VBAT_PARTIAL_0"
      sgroup "FG_BCL_VBAT_PARTIAL_0 (at 0x4264)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_VBAT_PARTIAL_1"
      sgroup "FG_BCL_VBAT_PARTIAL_1 (at 0x4265)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_VBAT_PARTIAL_0_CP"
      sgroup "FG_BCL_VBAT_PARTIAL_0_CP (at 0x4266)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_VBAT_PARTIAL_1_CP"
      sgroup "FG_BCL_VBAT_PARTIAL_1_CP (at 0x4267)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STS                                      = "
    tree.end
    tree "FG_BCL_BCL_CFG"
      sgroup "FG_BCL_BCL_CFG (at 0x426a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80426a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x426a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BGOCEN                                   = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_HALT_ON_BTFTOP                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BSHUTDWNRQ                               = " "0 (BCL_SHND_NOT_REQ),1 (BCL_SHND_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBTCMPCTL                                = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBTCMPCTLARB                             = " "0 (USE_LOGIC),1 (USE_REGISTER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BCNVCTL                                  = " "0 (BCL_MONITORING_DISABLE),1 (BCL_MONITORING_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BCNVCTLEN                                = " "0 (DISABLE_REG_CTRL),1 (ENABLE_BCL_REG_CTRL)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BCNVRREN                                 = " "0 (DISABLE_BCL_IN_RR),1 (ENABLE_BCL_IN_RR)"
    tree.end
    tree "FG_BCL_VBAT_CMP_CFG"
      sgroup "FG_BCL_VBAT_CMP_CFG (at 0x4270)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SLEEP_CFG                                = " "0 (DISABLE_ON_ADC),1 (ENABLE_ON_ADC)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   HYST_CTL                                 = " "0 (HYST_13P6PCT),1 (HYST_8P7PCT),2 (HYST_4P2PCT),3 (HYST_0PCT)"
    tree.end
    tree "FG_BCL_VBAT_ADC_LOW"
      sgroup "FG_BCL_VBAT_ADC_LOW (at 0x4272)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_BCL_VBAT_LOW"
      sgroup "FG_BCL_VBAT_LOW (at 0x4275)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   THR                                      = " "0 (V_2P5),1 (V_2P6),2 (V_2P7),3 (V_2P8),4 (V_2P9),5 (V_3),6 (V_3P1),7 (V_3P2)"
    tree.end
    tree "FG_BCL_VBAT_TOO_LOW"
      sgroup "FG_BCL_VBAT_TOO_LOW (at 0x4276)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   THR                                      = " "0 (TV_2P4),1 (TV_2P5),2 (TV_2P6),3 (TV_2P7),4 (TV_2P8),5 (TV_2P9),6 (TV_3),7 (TV_3P1)"
    tree.end
    tree "FG_BCL_IBATT_HIGH"
      sgroup "FG_BCL_IBATT_HIGH (at 0x4278)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_BCL_IBATT_TOO_HIGH"
      sgroup "FG_BCL_IBATT_TOO_HIGH (at 0x4279)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_BCL_IBATT_TOO_HIGH_STS"
      sgroup "FG_BCL_IBATT_TOO_HIGH_STS (at 0x427a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80427a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x427a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_BCL_IBATT_TOO_HIGH_MIN_STS"
      sgroup "FG_BCL_IBATT_TOO_HIGH_MIN_STS (at 0x427b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80427b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x427b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_BCL_IBATT_H_CFG"
      sgroup "FG_BCL_IBATT_H_CFG (at 0x4280)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_IBATT_TH_CFG"
      sgroup "FG_BCL_IBATT_TH_CFG (at 0x4281)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_VBATT_ADC_CFG"
      sgroup "FG_BCL_VBATT_ADC_CFG (at 0x4284)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_VBATT_L_CFG"
      sgroup "FG_BCL_VBATT_L_CFG (at 0x4286)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_VBATT_L_INT_CFG"
      sgroup "FG_BCL_VBATT_L_INT_CFG (at 0x4287)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_VBATT_TL_CFG"
      sgroup "FG_BCL_VBATT_TL_CFG (at 0x4288)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_VBATT_TL_INT_CFG"
      sgroup "FG_BCL_VBATT_TL_INT_CFG (at 0x4289)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_SLEEP_CFG"
      sgroup "FG_BCL_SLEEP_CFG (at 0x4290)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DX_DGL_SET_DELAY                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_BAN_TIMING_AX_DGL"
      sgroup "FG_BCL_BAN_TIMING_AX_DGL (at 0x4291)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   VBATT_TOO_HIGH_DELAY                     = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IBATT_TOO_HIGH_DELAY                     = "
    tree.end
    tree "FG_BCL_BAN_TIMING_DX"
      sgroup "FG_BCL_BAN_TIMING_DX (at 0x4292)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BAN_ASSERT_LOW_STRETCH                   = "
    tree.end
    tree "FG_BCL_LMH_FSM"
      sgroup "FG_BCL_LMH_FSM (at 0x42a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   STATE                                    = "
    tree.end
    tree "FG_BCL_LMH_FROM_BOB"
      sgroup "FG_BCL_LMH_FROM_BOB (at 0x42a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LEVEL_2                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LEVEL_1                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LEVEL_0                              = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_LMH_FROM_FLASH"
      sgroup "FG_BCL_LMH_FROM_FLASH (at 0x42a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LEVEL_2                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LEVEL_1                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LEVEL_0                              = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_LMH_CFG"
      sgroup "FG_BCL_LMH_CFG (at 0x42a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_TM_ENC                               = " "0 (ONE_HOT),1 (THERMOMETER_ENC)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_EN                                   = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BCL_LMH_DELAY_0"
      sgroup "FG_BCL_LMH_DELAY_0 (at 0x42a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL0_ST_EXIT_DGL                     = "
    tree.end
    tree "FG_BCL_LMH_DELAY_1"
      sgroup "FG_BCL_LMH_DELAY_1 (at 0x42a5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL1_ST_EXIT_DGL                     = "
    tree.end
    tree "FG_BCL_LMH_DELAY_2"
      sgroup "FG_BCL_LMH_DELAY_2 (at 0x42a6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LMH_LVL2_ST_EXIT_DGL                     = "
    tree.end
    tree "FG_BCL_LMH_SLCT_MTGT_PBS"
      sgroup "FG_BCL_LMH_SLCT_MTGT_PBS (at 0x42a7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SELECT_MITIGATION                        = " "0 (LMHDRV0),1 (LMHLVL0),2 (LMHLVL1),3 (LMHLVL2),4 (LMHBANDRV),5 (LMHBANPIN),6 (LMHDRV1),7 (reserved)"
    tree.end
    tree "FG_BCL_LMH_SLCT_MTGT_WIL"
      sgroup "FG_BCL_LMH_SLCT_MTGT_WIL (at 0x42a8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SELECT_MITIGATION                        = " "0 (LMHDRV0),1 (LMHLVL0),2 (LMHLVL1),3 (LMHLVL2),4 (LMHBANDRV),5 (LMHBANPIN),6 (LMHDRV1),7 (reserved)"
    tree.end
    tree "FG_BCL_LMH_SLCT_MTGT_FLASH"
      sgroup "FG_BCL_LMH_SLCT_MTGT_FLASH (at 0x42a9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SELECT_MITIGATION                        = " "0 (LMHDRV0),1 (LMHLVL0),2 (LMHLVL1),3 (LMHLVL2),4 (LMHBANDRV),5 (LMHBANPIN),6 (LMHDRV1),7 (reserved)"
    tree.end
    tree "FG_BCL_LMH_SLCT_MTGT_CRG"
      sgroup "FG_BCL_LMH_SLCT_MTGT_CRG (at 0x42aa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SELECT_MITIGATION                        = " "0 (LMHDRV0),1 (LMHLVL0),2 (LMHLVL1),3 (LMHLVL2),4 (LMHBANDRV),5 (LMHBANPIN),6 (LMHDRV1),7 (reserved)"
    tree.end
    tree "FG_BCL_LMH_BOB_DGL"
      sgroup "FG_BCL_LMH_BOB_DGL (at 0x42ab)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AX_DGL_SET_DELAY                         = "
    tree.end
    tree "FG_BCL_LMH_BOB_DGL_CTL"
      sgroup "FG_BCL_LMH_BOB_DGL_CTL (at 0x42ac)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DRV_OUT_AX                               = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLRAX                                    = " "0 (DO_NOT_CLEAR_DEGLITCHER),1 (CLEAR_DEGLITCHER_TIMER)"
    tree.end
    tree "FG_BCL_TREPN_STS"
      sgroup "FG_BCL_TREPN_STS (at 0x42b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRPNMISS                                 = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRPNDTAVAIL                              = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_TREPN_CFG"
      sgroup "FG_BCL_TREPN_CFG (at 0x42b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TREN_ENABLE                              = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_TREPN_RD_CFG"
      sgroup "FG_BCL_TREPN_RD_CFG (at 0x42b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ACCUMULATION_COUNTER                     = "
    tree.end
    tree "FG_BCL_TREPN_RD_CTL"
      sgroup "FG_BCL_TREPN_RD_CTL (at 0x42b4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_MISSING_CLEAR                       = " "0 (DO_NOT_CLEAR),1 (CLEAR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FINAL_VALUE_LOCK                         = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_TREPN_IBATT_LSB"
      sgroup "FG_BCL_TREPN_IBATT_LSB (at 0x42b6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FINAL_VALUE                              = "
    tree.end
    tree "FG_BCL_TREPN_IBATT_MSB"
      sgroup "FG_BCL_TREPN_IBATT_MSB (at 0x42b7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FINAL_VALUE                              = "
    tree.end
    tree "FG_BCL_TREPN_IB_LIVE_LSB"
      sgroup "FG_BCL_TREPN_IB_LIVE_LSB (at 0x42b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_TREPN_IB_LIVE_MSB"
      sgroup "FG_BCL_TREPN_IB_LIVE_MSB (at 0x42b9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_TREPN_SAMPLE_COUNT"
      sgroup "FG_BCL_TREPN_SAMPLE_COUNT (at 0x42ba)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_BATFET_OPEN_CFG"
      sgroup "FG_BCL_BATFET_OPEN_CFG (at 0x42c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BTFTOPRV_LOG_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BTFTOPRV_PBS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BTFTOPRV_EN                              = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "FG_BCL_BATFET_OPEN_AX_CTL"
      sgroup "FG_BCL_BATFET_OPEN_AX_CTL (at 0x42c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   SLCTDLY                                  = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DRV_OUT                                  = " "0 (DO_NOT_FORCE_OUTPUT),1 (FORCE_OUTPUT_0),2 (FORCE_OUTPUT_1),3 (ILLEGAL_FORCING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLRAX                                    = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_BATFET_OPEN_PX_CTL"
      sgroup "FG_BCL_BATFET_OPEN_PX_CTL (at 0x42c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENPX                                     = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DRV1                                     = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_X_CTL0_CFG"
      sgroup "FG_BCL_X_CTL0_CFG (at 0x42c4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN                                       = " "0 (NORMAL_OPERATION),1 (FORCE)"
    tree.end
    tree "FG_BCL_X_CTL1_CFG"
      sgroup "FG_BCL_X_CTL1_CFG (at 0x42c5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LCK                                      = " "0 (NORMAL_OPERATION),1 (FORCE)"
    tree.end
    tree "FG_BCL_X_CTL1_STS"
      sgroup "FG_BCL_X_CTL1_STS (at 0x42c6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LCK                                      = " "0 (NORMAL_OPERATION),1 (FORCE)"
    tree.end
    tree "FG_BCL_IBT_THI_MIN_CFG"
      sgroup "FG_BCL_IBT_THI_MIN_CFG (at 0x42c7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THR                                      = "
    tree.end
    tree "FG_BCL_IBT_THI_MIN_ACS_CFG"
      sgroup "FG_BCL_IBT_THI_MIN_ACS_CFG (at 0x42c8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LCK                                      = " "0, 1"
    tree.end
    tree "FG_BCL_IBT_THI_MIN_ACS_STS"
      sgroup "FG_BCL_IBT_THI_MIN_ACS_STS (at 0x42c9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042c90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42c90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LCK                                      = " "0, 1"
    tree.end
    tree "FG_BCL_SEC_ACCESS"
      sgroup "FG_BCL_SEC_ACCESS (at 0x42d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_BCL_PERPH_RESET_CTL2"
      sgroup "FG_BCL_PERPH_RESET_CTL2 (at 0x42d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_BCL_PERPH_RESET_CTL3"
      sgroup "FG_BCL_PERPH_RESET_CTL3 (at 0x42da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_BCL_PERPH_RESET_CTL4"
      sgroup "FG_BCL_PERPH_RESET_CTL4 (at 0x42db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_BCL_INT_TEST1"
      sgroup "FG_BCL_INT_TEST1 (at 0x42e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_BCL_INT_TEST_VAL"
      sgroup "FG_BCL_INT_TEST_VAL (at 0x42e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BCL_BUS_ERR                              = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRPN                                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBT_TLO_CMP                              = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBT_LO_CMP                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBT_LO_ADC                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IBT_THI                                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IBT_HI                                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "FG_BCL_TM_LMH_IDSS"
      sgroup "FG_BCL_TM_LMH_IDSS (at 0x42e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LMH_FORCE_LEVEL2                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_FORCE_LEVEL1                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_FORCE_LEVEL0                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_REG_DRIVEN                           = " "0 (USE_LOGIC),1 (ENABLE_REGISTER_CTRL)"
    tree.end
    tree "FG_BCL_TM_LMH_IDSS_STS"
      sgroup "FG_BCL_TM_LMH_IDSS_STS (at 0x42e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LEVEL_2                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LEVEL_1                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LEVEL_0                              = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_BCL_TM_LMH_BOB"
      sgroup "FG_BCL_TM_LMH_BOB (at 0x42e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LMH_FORCE_LEVEL2                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_FORCE_LEVEL1                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_FORCE_LEVEL0                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_REG_DRIVEN                           = " "0 (USE_LOGIC),1 (ENABLE_REGISTER_CTRL)"
    tree.end
    tree "FG_BCL_TM_LMH_FLASH"
      sgroup "FG_BCL_TM_LMH_FLASH (at 0x42e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LMH_FORCE_LEVEL2                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_FORCE_LEVEL1                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_FORCE_LEVEL0                         = " "0 (LOW),1 (HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_REG_DRIVEN                           = " "0 (USE_LOGIC),1 (ENABLE_REGISTER_CTRL)"
    tree.end
    tree "FG_BCL_TM_BCL_ADC"
      sgroup "FG_BCL_TM_BCL_ADC (at 0x42e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BCL_VBATT_CMP_FRC                        = " "0 (NO_FORCE),1 (FORCE_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BCL_VADC_CONV                            = " "0 (CONVERSION_NOT_REQUESTED),1 (CONVERSION_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BCL_IADC_CONV                            = " "0 (CONVERSION_NOT_REQUESTED),1 (CONVERSION_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_ENABLE_REG_DRIVEN                    = " "0 (USE_LOGIC),1 (ENABLE_REGISTER_CTRL)"
    tree.end
    tree "FG_BCL_TM_BCL_IADC"
      sgroup "FG_BCL_TM_BCL_IADC (at 0x42e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_DONE                                = " "0 (CONVERSION_IN_PROGRESS),1 (CONVERSION_DONE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_TM_BCL_VADC"
      sgroup "FG_BCL_TM_BCL_VADC (at 0x42e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_DONE                                = " "0 (CONVERSION_IN_PROGRESS),1 (CONVERSION_DONE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VALUE                                    = "
    tree.end
    tree "FG_BCL_TM_BATFET_OPEN"
      sgroup "FG_BCL_TM_BATFET_OPEN (at 0x42e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BATFET_OPEN_CTL                          = " "0 (BETFET_CLOSED),1 (BATFET_OPEN_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATFET_OPEN_REG_DRIVEN                   = " "0 (USE_LOGIC),1 (ENABLE_REGISTER_CTRL)"
    tree.end
    tree "FG_BCL_TM_BCL_MODE"
      sgroup "FG_BCL_TM_BCL_MODE (at 0x42ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BCL_MODE                                 = " "0 (BCL_IS_LPM),1 (BCL_IS_HPM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BCL_MODE_FROM_FG                         = " "0 (USE_LOGIC),1 (USE_REGISTER)"
    tree.end
    tree "FG_BCL_TRIM_NUM"
      sgroup "FG_BCL_TRIM_NUM (at 0x42f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_NUM                                 = "
    tree.end
    tree "FG_BCL_BCL_V_GAIN_BATT_TRIM"
      sgroup "FG_BCL_BCL_V_GAIN_BATT_TRIM (at 0x42f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_BCL_BCL_I_GAIN_RSENSE_TRIM"
      sgroup "FG_BCL_BCL_I_GAIN_RSENSE_TRIM (at 0x42f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
    tree "FG_BCL_BCL_I_GAIN_BATFET_TRIM"
      sgroup "FG_BCL_BCL_I_GAIN_BATFET_TRIM (at 0x42f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VAL                                      = "
    tree.end
  tree.end
tree.end
tree "FG_DMA0"
tree.end
tree "FG_DMA1"
tree.end
tree "FG_DMA2"
tree.end
tree "FG_DMA3"
tree.end
tree "FG_FT_HDR"
  tree "FG_FT_HDR"
    tree "FG_FT_HDR_REVISION1"
      sgroup "FG_FT_HDR_REVISION1 (at 0x4600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "FG_FT_HDR_REVISION2"
      sgroup "FG_FT_HDR_REVISION2 (at 0x4601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "FG_FT_HDR_PERPH_TYPE"
      sgroup "FG_FT_HDR_PERPH_TYPE (at 0x4604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_FT_HDR_PERPH_SUBTYPE"
      sgroup "FG_FT_HDR_PERPH_SUBTYPE (at 0x4605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC0_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC0_BYTE1 (at 0x4620)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046200
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46200
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC0_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC0_BYTE2 (at 0x4621)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046210
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46210
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC0_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC0_BYTE3 (at 0x4622)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046220
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46220
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC1_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC1_BYTE1 (at 0x4623)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046230
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46230
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC1_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC1_BYTE2 (at 0x4624)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046240
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46240
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC1_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC1_BYTE3 (at 0x4625)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046250
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46250
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC2_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC2_BYTE1 (at 0x4626)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046260
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46260
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC2_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC2_BYTE2 (at 0x4627)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046270
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46270
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC2_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC2_BYTE3 (at 0x4628)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046280
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46280
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC3_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC3_BYTE1 (at 0x4629)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046290
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46290
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC3_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC3_BYTE2 (at 0x462a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80462a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x462a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC3_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC3_BYTE3 (at 0x462b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80462b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x462b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC4_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC4_BYTE1 (at 0x462c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80462c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x462c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC4_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC4_BYTE2 (at 0x462d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80462d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x462d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_SOC4_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_SOC4_BYTE3 (at 0x462e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80462e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x462e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL5_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL5_BYTE1 (at 0x462f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80462f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x462f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL5_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL5_BYTE2 (at 0x4630)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046300
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46300
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL5_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL5_BYTE3 (at 0x4631)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046310
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46310
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL6_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL6_BYTE1 (at 0x4632)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046320
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46320
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL6_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL6_BYTE2 (at 0x4633)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046330
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46330
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL6_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL6_BYTE3 (at 0x4634)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046340
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46340
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL7_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL7_BYTE1 (at 0x4635)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046350
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46350
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL7_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL7_BYTE2 (at 0x4636)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046360
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46360
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL7_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL7_BYTE3 (at 0x4637)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046370
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46370
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL8_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL8_BYTE1 (at 0x4638)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046380
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46380
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL8_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL8_BYTE2 (at 0x4639)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046390
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46390
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL8_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL8_BYTE3 (at 0x463a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80463a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x463a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL9_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL9_BYTE1 (at 0x463b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80463b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x463b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL9_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL9_BYTE2 (at 0x463c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80463c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x463c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL9_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL9_BYTE3 (at 0x463d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80463d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x463d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL10_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL10_BYTE1 (at 0x463e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80463e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x463e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL10_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL10_BYTE2 (at 0x463f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80463f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x463f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL10_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL10_BYTE3 (at 0x4640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL11_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL11_BYTE1 (at 0x4641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL11_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL11_BYTE2 (at 0x4642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL11_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL11_BYTE3 (at 0x4643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL12_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL12_BYTE1 (at 0x4644)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL12_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL12_BYTE2 (at 0x4645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL12_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL12_BYTE3 (at 0x4646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL13_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL13_BYTE1 (at 0x4647)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL13_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL13_BYTE2 (at 0x4648)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BCL13_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BCL13_BYTE3 (at 0x4649)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO14_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO14_BYTE1 (at 0x464a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO14_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO14_BYTE2 (at 0x464b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO14_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO14_BYTE3 (at 0x464c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO15_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO15_BYTE1 (at 0x464d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO15_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO15_BYTE2 (at 0x464e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO15_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO15_BYTE3 (at 0x464f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80464f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x464f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO16_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO16_BYTE1 (at 0x4650)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO16_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO16_BYTE2 (at 0x4651)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO16_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO16_BYTE3 (at 0x4652)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO17_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO17_BYTE1 (at 0x4653)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO17_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO17_BYTE2 (at 0x4654)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO17_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO17_BYTE3 (at 0x4655)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO18_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO18_BYTE1 (at 0x4656)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO18_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO18_BYTE2 (at 0x4657)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO18_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO18_BYTE3 (at 0x4658)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO19_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO19_BYTE1 (at 0x4659)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO19_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO19_BYTE2 (at 0x465a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80465a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x465a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO19_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO19_BYTE3 (at 0x465b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80465b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x465b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO20_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO20_BYTE1 (at 0x465c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80465c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x465c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO20_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO20_BYTE2 (at 0x465d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80465d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x465d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO20_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO20_BYTE3 (at 0x465e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80465e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x465e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO21_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO21_BYTE1 (at 0x465f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80465f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x465f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO21_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO21_BYTE2 (at 0x4660)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO21_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO21_BYTE3 (at 0x4661)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO22_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO22_BYTE1 (at 0x4662)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO22_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO22_BYTE2 (at 0x4663)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_BATT_INFO22_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_BATT_INFO22_BYTE3 (at 0x4664)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR23_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR23_BYTE1 (at 0x4665)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR23_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR23_BYTE2 (at 0x4666)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR23_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR23_BYTE3 (at 0x4667)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR24_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR24_BYTE1 (at 0x4668)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR24_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR24_BYTE2 (at 0x4669)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR24_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR24_BYTE3 (at 0x466a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR25_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR25_BYTE1 (at 0x466b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR25_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR25_BYTE2 (at 0x466c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR25_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR25_BYTE3 (at 0x466d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR26_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR26_BYTE1 (at 0x466e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR26_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR26_BYTE2 (at 0x466f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80466f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x466f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR26_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR26_BYTE3 (at 0x4670)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR27_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR27_BYTE1 (at 0x4671)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR27_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR27_BYTE2 (at 0x4672)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR27_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR27_BYTE3 (at 0x4673)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR28_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR28_BYTE1 (at 0x4674)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR28_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR28_BYTE2 (at 0x4675)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_ADC_RR28_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_ADC_RR28_BYTE3 (at 0x4676)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH29_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH29_BYTE1 (at 0x4677)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH29_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH29_BYTE2 (at 0x4678)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH29_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH29_BYTE3 (at 0x4679)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH30_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH30_BYTE1 (at 0x467a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80467a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x467a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH30_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH30_BYTE2 (at 0x467b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80467b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x467b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH30_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH30_BYTE3 (at 0x467c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80467c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x467c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH31_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH31_BYTE1 (at 0x467d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80467d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x467d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH31_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH31_BYTE2 (at 0x467e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80467e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x467e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_LMH31_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_LMH31_BYTE3 (at 0x467f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80467f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x467f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF32_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF32_BYTE1 (at 0x4680)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF32_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF32_BYTE2 (at 0x4681)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF32_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF32_BYTE3 (at 0x4682)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF33_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF33_BYTE1 (at 0x4683)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF33_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF33_BYTE2 (at 0x4684)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF33_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF33_BYTE3 (at 0x4685)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF34_BYTE1"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF34_BYTE1 (at 0x4686)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF34_BYTE2"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF34_BYTE2 (at 0x4687)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "FG_FT_HDR_FTRIM_FG_MEM_IF34_BYTE3"
      sgroup "FG_FT_HDR_FTRIM_FG_MEM_IF34_BYTE3 (at 0x4688)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   NUM                                      = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SID                                      = " "0, 1, 2, 3"
    tree.end
    tree "FG_FT_HDR_END_TRIM_COPY_SUBROUTINE"
      sgroup "FG_FT_HDR_END_TRIM_COPY_SUBROUTINE (at 0x4689)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
  tree.end
tree.end
tree "FG_LMH"
  tree "FG_LMH"
    tree "FG_LMH_PERPH_TYPE"
      sgroup "FG_LMH_PERPH_TYPE (at 0x4304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_LMH_PERPH_SUBTYPE"
      sgroup "FG_LMH_PERPH_SUBTYPE (at 0x4305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_LMH_INT_RT_STS"
      sgroup "FG_LMH_INT_RT_STS (at 0x4310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "FG_LMH_INT_SET_TYPE"
      sgroup "FG_LMH_INT_SET_TYPE (at 0x4311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_LMH_INT_POLARITY_HIGH"
      sgroup "FG_LMH_INT_POLARITY_HIGH (at 0x4312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_LMH_INT_POLARITY_LOW"
      sgroup "FG_LMH_INT_POLARITY_LOW (at 0x4313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_LMH_INT_LATCHED_CLR"
      sgroup "FG_LMH_INT_LATCHED_CLR (at 0x4314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0, 1"
    tree.end
    tree "FG_LMH_INT_EN_SET"
      sgroup "FG_LMH_INT_EN_SET (at 0x4315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_LMH_INT_EN_CLR"
      sgroup "FG_LMH_INT_EN_CLR (at 0x4316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "FG_LMH_INT_LATCHED_STS"
      sgroup "FG_LMH_INT_LATCHED_STS (at 0x4318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "FG_LMH_INT_PENDING_STS"
      sgroup "FG_LMH_INT_PENDING_STS (at 0x4319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "FG_LMH_INT_MID_SEL"
      sgroup "FG_LMH_INT_MID_SEL (at 0x431a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_LMH_INT_PRIORITY"
      sgroup "FG_LMH_INT_PRIORITY (at 0x431b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "FG_LMH_INT_VIRTUAL_OUTPUT"
      sgroup "FG_LMH_INT_VIRTUAL_OUTPUT (at 0x431c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_VIRTUAL_OUTPUT                       = " "0 (NORMAL),1 (VIRTUAL_OUTPUT)"
    tree.end
    tree "FG_LMH_SEC_ACCESS"
      sgroup "FG_LMH_SEC_ACCESS (at 0x43d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_LMH_PERPH_RESET_CTL2"
      sgroup "FG_LMH_PERPH_RESET_CTL2 (at 0x43d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_LMH_PERPH_RESET_CTL3"
      sgroup "FG_LMH_PERPH_RESET_CTL3 (at 0x43da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_LMH_PERPH_RESET_CTL4"
      sgroup "FG_LMH_PERPH_RESET_CTL4 (at 0x43db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "FG_LMH_INT_TEST1"
      sgroup "FG_LMH_INT_TEST1 (at 0x43e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "FG_LMH_INT_TEST_VAL"
      sgroup "FG_LMH_INT_TEST_VAL (at 0x43e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LMH_LVL2                                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LMH_LVL1                                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LMH_LVL0                                 = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "FG_MEM_IF"
  tree "FG_MEM_IF"
    tree "FG_MEM_IF_REVISION1"
      sgroup "FG_MEM_IF_REVISION1 (at 0x4400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "FG_MEM_IF_REVISION2"
      sgroup "FG_MEM_IF_REVISION2 (at 0x4401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "FG_MEM_IF_REVISION3"
      sgroup "FG_MEM_IF_REVISION3 (at 0x4402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "FG_MEM_IF_REVISION4"
      sgroup "FG_MEM_IF_REVISION4 (at 0x4403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "FG_MEM_IF_PERPH_TYPE"
      sgroup "FG_MEM_IF_PERPH_TYPE (at 0x4404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "FG_MEM_IF_PERPH_SUBTYPE"
      sgroup "FG_MEM_IF_PERPH_SUBTYPE (at 0x4405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "FG_MEM_IF_MEM_STS"
      sgroup "FG_MEM_IF_MEM_STS (at 0x4406)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MEM_CYC_STRETCH                          = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_MEM_IF_IMA_RDY_STS"
      sgroup "FG_MEM_IF_IMA_RDY_STS (at 0x4407)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IACS_RDY                                 = " "0 (INTERLEAVE_ACS_IN_PROGRESS),1 (INTERLEAVE_ACS_IDLE)"
    tree.end
    tree "FG_MEM_IF_INT_RT_STS"
      sgroup "FG_MEM_IF_INT_RT_STS (at 0x4410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (NOT_GRANTED),1 (GRANTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (IMA_EXCEPTION_FALSE),1 (IMA_EXCEPTION_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (FG_MEM_ST0),1 (FG_MEM_ST1)"
    tree.end
    tree "FG_MEM_IF_INT_SET_TYPE"
      sgroup "FG_MEM_IF_INT_SET_TYPE (at 0x4411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "FG_MEM_IF_INT_POLARITY_HIGH"
      sgroup "FG_MEM_IF_INT_POLARITY_HIGH (at 0x4412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "FG_MEM_IF_INT_POLARITY_LOW"
      sgroup "FG_MEM_IF_INT_POLARITY_LOW (at 0x4413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "FG_MEM_IF_INT_LATCHED_CLR"
      sgroup "FG_MEM_IF_INT_LATCHED_CLR (at 0x4414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (INT_LATCH_CLEAR_FALSE),1 (INT_LATCH_CLEAR_TRUE)"
    tree.end
    tree "FG_MEM_IF_INT_EN_SET"
      sgroup "FG_MEM_IF_INT_EN_SET (at 0x4415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (INT_ENABLED_FALSE),1 (INT_ENABLED_TRUE)"
    tree.end
    tree "FG_MEM_IF_INT_EN_CLR"
      sgroup "FG_MEM_IF_INT_EN_CLR (at 0x4416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (INT_DISABLED_FALSE),1 (INT_DISABLED_TRUE)"
    tree.end
    tree "FG_MEM_IF_INT_LATCHED_STS"
      sgroup "FG_MEM_IF_INT_LATCHED_STS (at 0x4418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (INT_TRIGGERED_FALSE),1 (INT_TRIGGERED_TRUE)"
    tree.end
    tree "FG_MEM_IF_INT_PENDING_STS"
      sgroup "FG_MEM_IF_INT_PENDING_STS (at 0x4419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (INT_PENDING_FALSE),1 (INT_PENDING_TRUE)"
    tree.end
    tree "FG_MEM_IF_INT_MID_SEL"
      sgroup "FG_MEM_IF_INT_MID_SEL (at 0x441a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "FG_MEM_IF_INT_PRIORITY"
      sgroup "FG_MEM_IF_INT_PRIORITY (at 0x441b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY0),1 (INT_PRIORITY1)"
    tree.end
    tree "FG_MEM_IF_MEM_ARB_CFG"
      sgroup "FG_MEM_IF_MEM_ARB_CFG (at 0x4440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_CLR_LOG                              = " "0 (CLR_LOG_FALSE),1 (CLR_LOG_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_ARB_LO_LATENCY_EN                    = " "0 (HI_LATENCY),1 (LO_LATENCY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MEM_ARB_REQ                              = " "0 (NO_MEM_REQ),1 (MEM_REQ)"
    tree.end
    tree "FG_MEM_IF_MEM_INTF_CFG"
      sgroup "FG_MEM_IF_MEM_INTF_CFG (at 0x4450)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEM_ACCESS_REQ                           = " "0 (MEM_ACCESS_REQ_FALSE),1 (MEM_ACCESS_REQ_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IACS_SLCT                                = " "0 (SELECT_DMA),1 (SELECT_IMA)"
    tree.end
    tree "FG_MEM_IF_IMA_CTL"
      sgroup "FG_MEM_IF_IMA_CTL (at 0x4451)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (MEM_ACS_SINGLE),1 (MEM_ACS_BURST)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "FG_MEM_IF_IMA_CFG"
      sgroup "FG_MEM_IF_IMA_CFG (at 0x4452)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_WR_FGXCT_PRD                          = " "0 (DISABLE_WR_FGXCT_PRD),1 (ENABLE_WR_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_RD_FGXCT_PRD                          = " "0 (DISABLE_RD_FGXCT_PRD),1 (ENABLE_RD_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STATIC_CLK_EN                            = " "0 (IACS_DYNAMIC_CLK_EN),1 (IACS_STATIC_CLK_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IACS_INTR_SRC_SLCT                       = " "0 (END_OF_TRANSACTION),1 (IACS_RDY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IACS_CLR                                 = " "0 (IACS_NORMAL_MODE),1 (IACS_CLEAR_MODE)"
    tree.end
    tree "FG_MEM_IF_IMA_OPERATION_STS"
      sgroup "FG_MEM_IF_IMA_OPERATION_STS (at 0x4454)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FGXCT_PRD                                = " "0 (FG_FREE_PRD),1 (FG_XCT_PERIOD)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_FGXCT_PRD_LOG                         = " "0 (INTERLEAVE_WR_FGFREE_PRD),1 (INTERLEAVE_WR_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   RD_FGXCT_PRD_LOG                         = " "0 (INTERLEAVE_RD_FGFREE_PRD),1 (INTERLEAVE_RD_FGXCT_PRD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IACS_CLK_REQ                             = " "0 (INTERLEAVE_ACS_CLK_REQ_IDLE),1 (INTERLEAVE_ACS_CLK_REQ_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IACS_INTR_STS                            = " "0 (IACS_INTR_IDLE),1 (IACS_INTR_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IACS_RDY                                 = " "0 (INTERLEAVE_ACS_IN_PROGRESS),1 (INTERLEAVE_ACS_IDLE)"
    tree.end
    tree "FG_MEM_IF_IMA_EXCEPTION_STS"
      sgroup "FG_MEM_IF_IMA_EXCEPTION_STS (at 0x4455)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADDR_STABLE_ERR                          = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ADDR_BURST_WRAP                          = " "0 (NO_WRAP),1 (WRAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DATA_WR_ERR                              = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DATA_RD_ERR                              = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BE_BURSTWR_WARN                          = " "0 (NO_WARN),1 (WARN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   XCT_TYPE_ERR                             = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IACS_ERR                                 = " "0 (NO_ERR),1 (ERR)"
    tree.end
    tree "FG_MEM_IF_IMA_HARDWARE_STS"
      sgroup "FG_MEM_IF_IMA_HARDWARE_STS (at 0x4456)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADDR_MSB_WR_TGL                          = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DATA_MSB_WR_TGL                          = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DATA_MSB_RD_TGL                          = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADDR_MSB_WR_TGL_RCV                      = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DATA_MSB_WR_TGL_RCV                      = " "0 (ST0),1 (ST1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DATA_MSB_RD_TGL_RCV                      = " "0 (ST0),1 (ST1)"
    tree.end
    tree "FG_MEM_IF_FG_BEAT_COUNT"
      sgroup "FG_MEM_IF_FG_BEAT_COUNT (at 0x4457)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   BEAT_CNT                                 = "
    tree.end
    tree "FG_MEM_IF_IMA_ERR_STS"
      sgroup "FG_MEM_IF_IMA_ERR_STS (at 0x445f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80445f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x445f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADDR_STBL_ERR                            = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_ACS_ERR                               = " "0 (NO_ERR),1 (ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   RD_ACS_ERR                               = " "0 (NO_ERR),1 (ERR)"
    tree.end
    tree "FG_MEM_IF_IMA_BYTE_EN"
      sgroup "FG_MEM_IF_IMA_BYTE_EN (at 0x4460)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BE3                                      = " "0 (BE3_DSBL),1 (BE3_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BE2                                      = " "0 (BE2_DSBL),1 (BE2_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BE1                                      = " "0 (BE1_DSBL),1 (BE1_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BE0                                      = " "0 (BE0_DSBL),1 (BE0_EN)"
    tree.end
    tree "FG_MEM_IF_IMA_ADDR_LSB"
      sgroup "FG_MEM_IF_IMA_ADDR_LSB (at 0x4461)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADDR                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_ADDR_MSB"
      sgroup "FG_MEM_IF_IMA_ADDR_MSB (at 0x4462)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADDR                                     = " "0, 1"
    tree.end
    tree "FG_MEM_IF_IMA_WR_DATA_7_0"
      sgroup "FG_MEM_IF_IMA_WR_DATA_7_0 (at 0x4463)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_WR_DATA_15_8"
      sgroup "FG_MEM_IF_IMA_WR_DATA_15_8 (at 0x4464)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_WR_DATA_23_16"
      sgroup "FG_MEM_IF_IMA_WR_DATA_23_16 (at 0x4465)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_WR_DATA_31_24"
      sgroup "FG_MEM_IF_IMA_WR_DATA_31_24 (at 0x4466)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_RD_DATA_7_0"
      sgroup "FG_MEM_IF_IMA_RD_DATA_7_0 (at 0x4467)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_RD_DATA_15_8"
      sgroup "FG_MEM_IF_IMA_RD_DATA_15_8 (at 0x4468)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_RD_DATA_23_16"
      sgroup "FG_MEM_IF_IMA_RD_DATA_23_16 (at 0x4469)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_IMA_RD_DATA_31_24"
      sgroup "FG_MEM_IF_IMA_RD_DATA_31_24 (at 0x446a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80446a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x446a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "FG_MEM_IF_DMA_STS"
      sgroup "FG_MEM_IF_DMA_STS (at 0x4470)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   READ_ERROR                               = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WRITE_ERROR                              = " "0 (FALSE),1 (TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GRANT                                    = " "0 (FALSE),1 (TRUE)"
    tree.end
    tree "FG_MEM_IF_DMA_CTL"
      sgroup "FG_MEM_IF_DMA_CTL (at 0x4471)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ADDR_KIND                                = " "0 (STRUCTURAL),1 (PARTITION)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLEAR_LOG                                = " "0 (CLR_LOG_FALSE),1 (CLR_LOG_TRUE)"
    tree.end
    tree "FG_MEM_IF_SEC_ACCESS"
      sgroup "FG_MEM_IF_SEC_ACCESS (at 0x44d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "FG_MEM_IF_PERPH_RESET_CTL2"
      sgroup "FG_MEM_IF_PERPH_RESET_CTL2 (at 0x44d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "FG_MEM_IF_PERPH_RESET_CTL3"
      sgroup "FG_MEM_IF_PERPH_RESET_CTL3 (at 0x44da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "FG_MEM_IF_PERPH_RESET_CTL4"
      sgroup "FG_MEM_IF_PERPH_RESET_CTL4 (at 0x44db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "FG_MEM_IF_INT_TEST1"
      sgroup "FG_MEM_IF_INT_TEST1 (at 0x44e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLE),1 (INT_TEST_MODE_ENABLE)"
    tree.end
    tree "FG_MEM_IF_INT_TEST_VAL"
      sgroup "FG_MEM_IF_INT_TEST_VAL (at 0x44e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FG_PEEKMUX                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEM_GNT                                  = " "0 (DATA_RCVRY_SUG_INT_TEST_VAL_FALSE),1 (DATA_RCVRY_SUG_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MEM_XCP                                  = " "0 (IMA_XCP_INT_TEST_VAL_FALSE),1 (IMA_XCP_INT_TEST_VAL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   IMA_RDY                                  = " "0 (FG_MEM_INT_TEST_VAL_FALSE),1 (FG_MEM_AVAIL_INT_TEST_VAL_TRUE)"
    tree.end
  tree.end
tree.end
tree "GPIO01"
  tree "GPIO01"
    tree "GPIO01_REVISION1"
      sgroup "GPIO01_REVISION1 (at 0xc000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO01_REVISION2"
      sgroup "GPIO01_REVISION2 (at 0xc001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO01_REVISION3"
      sgroup "GPIO01_REVISION3 (at 0xc002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO01_REVISION4"
      sgroup "GPIO01_REVISION4 (at 0xc003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO01_PERPH_TYPE"
      sgroup "GPIO01_PERPH_TYPE (at 0xc004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO01_PERPH_SUBTYPE"
      sgroup "GPIO01_PERPH_SUBTYPE (at 0xc005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO01_STATUS1"
      sgroup "GPIO01_STATUS1 (at 0xc008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO01_INT_RT_STS"
      sgroup "GPIO01_INT_RT_STS (at 0xc010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO01_INT_SET_TYPE"
      sgroup "GPIO01_INT_SET_TYPE (at 0xc011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO01_INT_POLARITY_HIGH"
      sgroup "GPIO01_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO01_INT_POLARITY_LOW"
      sgroup "GPIO01_INT_POLARITY_LOW (at 0xc013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO01_INT_LATCHED_CLR"
      sgroup "GPIO01_INT_LATCHED_CLR (at 0xc014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO01_INT_EN_SET"
      sgroup "GPIO01_INT_EN_SET (at 0xc015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO01_INT_EN_CLR"
      sgroup "GPIO01_INT_EN_CLR (at 0xc016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO01_INT_LATCHED_STS"
      sgroup "GPIO01_INT_LATCHED_STS (at 0xc018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO01_INT_PENDING_STS"
      sgroup "GPIO01_INT_PENDING_STS (at 0xc019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO01_INT_MID_SEL"
      sgroup "GPIO01_INT_MID_SEL (at 0xc01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO01_INT_PRIORITY"
      sgroup "GPIO01_INT_PRIORITY (at 0xc01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO01_MODE_CTL"
      sgroup "GPIO01_MODE_CTL (at 0xc040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO01_DIG_VIN_CTL"
      sgroup "GPIO01_DIG_VIN_CTL (at 0xc041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO01_DIG_PULL_CTL"
      sgroup "GPIO01_DIG_PULL_CTL (at 0xc042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO01_DIG_IN_DTEST_SEL"
      sgroup "GPIO01_DIG_IN_DTEST_SEL (at 0xc043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO01_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO01_DIG_OUT_SOURCE_CTL (at 0xc044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO01_DIG_OUT_DRV_CTL"
      sgroup "GPIO01_DIG_OUT_DRV_CTL (at 0xc045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO01_EN_CTL"
      sgroup "GPIO01_EN_CTL (at 0xc046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO01_ANA_PASS_THRU_SEL"
      sgroup "GPIO01_ANA_PASS_THRU_SEL (at 0xc04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO01_SEC_ACCESS"
      sgroup "GPIO01_SEC_ACCESS (at 0xc0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO01_PERPH_RESET_CTL1"
      sgroup "GPIO01_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO01_PERPH_RESET_CTL2"
      sgroup "GPIO01_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO01_PERPH_RESET_CTL3"
      sgroup "GPIO01_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO01_PERPH_RESET_CTL4"
      sgroup "GPIO01_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO02"
  tree "GPIO02"
    tree "GPIO02_REVISION1"
      sgroup "GPIO02_REVISION1 (at 0xc100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO02_REVISION2"
      sgroup "GPIO02_REVISION2 (at 0xc101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO02_REVISION3"
      sgroup "GPIO02_REVISION3 (at 0xc102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO02_REVISION4"
      sgroup "GPIO02_REVISION4 (at 0xc103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO02_PERPH_TYPE"
      sgroup "GPIO02_PERPH_TYPE (at 0xc104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO02_PERPH_SUBTYPE"
      sgroup "GPIO02_PERPH_SUBTYPE (at 0xc105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO02_STATUS1"
      sgroup "GPIO02_STATUS1 (at 0xc108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO02_INT_RT_STS"
      sgroup "GPIO02_INT_RT_STS (at 0xc110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO02_INT_SET_TYPE"
      sgroup "GPIO02_INT_SET_TYPE (at 0xc111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO02_INT_POLARITY_HIGH"
      sgroup "GPIO02_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO02_INT_POLARITY_LOW"
      sgroup "GPIO02_INT_POLARITY_LOW (at 0xc113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO02_INT_LATCHED_CLR"
      sgroup "GPIO02_INT_LATCHED_CLR (at 0xc114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO02_INT_EN_SET"
      sgroup "GPIO02_INT_EN_SET (at 0xc115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO02_INT_EN_CLR"
      sgroup "GPIO02_INT_EN_CLR (at 0xc116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO02_INT_LATCHED_STS"
      sgroup "GPIO02_INT_LATCHED_STS (at 0xc118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO02_INT_PENDING_STS"
      sgroup "GPIO02_INT_PENDING_STS (at 0xc119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO02_INT_MID_SEL"
      sgroup "GPIO02_INT_MID_SEL (at 0xc11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO02_INT_PRIORITY"
      sgroup "GPIO02_INT_PRIORITY (at 0xc11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO02_MODE_CTL"
      sgroup "GPIO02_MODE_CTL (at 0xc140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO02_DIG_VIN_CTL"
      sgroup "GPIO02_DIG_VIN_CTL (at 0xc141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO02_DIG_PULL_CTL"
      sgroup "GPIO02_DIG_PULL_CTL (at 0xc142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO02_DIG_IN_DTEST_SEL"
      sgroup "GPIO02_DIG_IN_DTEST_SEL (at 0xc143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO02_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO02_DIG_OUT_SOURCE_CTL (at 0xc144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO02_DIG_OUT_DRV_CTL"
      sgroup "GPIO02_DIG_OUT_DRV_CTL (at 0xc145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO02_EN_CTL"
      sgroup "GPIO02_EN_CTL (at 0xc146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO02_ANA_PASS_THRU_SEL"
      sgroup "GPIO02_ANA_PASS_THRU_SEL (at 0xc14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO02_SEC_ACCESS"
      sgroup "GPIO02_SEC_ACCESS (at 0xc1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO02_PERPH_RESET_CTL1"
      sgroup "GPIO02_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO02_PERPH_RESET_CTL2"
      sgroup "GPIO02_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO02_PERPH_RESET_CTL3"
      sgroup "GPIO02_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO02_PERPH_RESET_CTL4"
      sgroup "GPIO02_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO03"
  tree "GPIO03"
    tree "GPIO03_REVISION1"
      sgroup "GPIO03_REVISION1 (at 0xc200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO03_REVISION2"
      sgroup "GPIO03_REVISION2 (at 0xc201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO03_REVISION3"
      sgroup "GPIO03_REVISION3 (at 0xc202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO03_REVISION4"
      sgroup "GPIO03_REVISION4 (at 0xc203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO03_PERPH_TYPE"
      sgroup "GPIO03_PERPH_TYPE (at 0xc204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO03_PERPH_SUBTYPE"
      sgroup "GPIO03_PERPH_SUBTYPE (at 0xc205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO03_STATUS1"
      sgroup "GPIO03_STATUS1 (at 0xc208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO03_INT_RT_STS"
      sgroup "GPIO03_INT_RT_STS (at 0xc210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO03_INT_SET_TYPE"
      sgroup "GPIO03_INT_SET_TYPE (at 0xc211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO03_INT_POLARITY_HIGH"
      sgroup "GPIO03_INT_POLARITY_HIGH (at 0xc212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO03_INT_POLARITY_LOW"
      sgroup "GPIO03_INT_POLARITY_LOW (at 0xc213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO03_INT_LATCHED_CLR"
      sgroup "GPIO03_INT_LATCHED_CLR (at 0xc214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO03_INT_EN_SET"
      sgroup "GPIO03_INT_EN_SET (at 0xc215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO03_INT_EN_CLR"
      sgroup "GPIO03_INT_EN_CLR (at 0xc216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO03_INT_LATCHED_STS"
      sgroup "GPIO03_INT_LATCHED_STS (at 0xc218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO03_INT_PENDING_STS"
      sgroup "GPIO03_INT_PENDING_STS (at 0xc219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO03_INT_MID_SEL"
      sgroup "GPIO03_INT_MID_SEL (at 0xc21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO03_INT_PRIORITY"
      sgroup "GPIO03_INT_PRIORITY (at 0xc21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO03_MODE_CTL"
      sgroup "GPIO03_MODE_CTL (at 0xc240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO03_DIG_VIN_CTL"
      sgroup "GPIO03_DIG_VIN_CTL (at 0xc241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO03_DIG_PULL_CTL"
      sgroup "GPIO03_DIG_PULL_CTL (at 0xc242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO03_DIG_IN_DTEST_SEL"
      sgroup "GPIO03_DIG_IN_DTEST_SEL (at 0xc243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO03_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO03_DIG_OUT_SOURCE_CTL (at 0xc244)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO03_DIG_OUT_DRV_CTL"
      sgroup "GPIO03_DIG_OUT_DRV_CTL (at 0xc245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO03_EN_CTL"
      sgroup "GPIO03_EN_CTL (at 0xc246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO03_ANA_PASS_THRU_SEL"
      sgroup "GPIO03_ANA_PASS_THRU_SEL (at 0xc24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO03_SEC_ACCESS"
      sgroup "GPIO03_SEC_ACCESS (at 0xc2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO03_PERPH_RESET_CTL1"
      sgroup "GPIO03_PERPH_RESET_CTL1 (at 0xc2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO03_PERPH_RESET_CTL2"
      sgroup "GPIO03_PERPH_RESET_CTL2 (at 0xc2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO03_PERPH_RESET_CTL3"
      sgroup "GPIO03_PERPH_RESET_CTL3 (at 0xc2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO03_PERPH_RESET_CTL4"
      sgroup "GPIO03_PERPH_RESET_CTL4 (at 0xc2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO04"
  tree "GPIO04"
    tree "GPIO04_REVISION1"
      sgroup "GPIO04_REVISION1 (at 0xc300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO04_REVISION2"
      sgroup "GPIO04_REVISION2 (at 0xc301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO04_REVISION3"
      sgroup "GPIO04_REVISION3 (at 0xc302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO04_REVISION4"
      sgroup "GPIO04_REVISION4 (at 0xc303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO04_PERPH_TYPE"
      sgroup "GPIO04_PERPH_TYPE (at 0xc304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO04_PERPH_SUBTYPE"
      sgroup "GPIO04_PERPH_SUBTYPE (at 0xc305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO04_STATUS1"
      sgroup "GPIO04_STATUS1 (at 0xc308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO04_INT_RT_STS"
      sgroup "GPIO04_INT_RT_STS (at 0xc310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO04_INT_SET_TYPE"
      sgroup "GPIO04_INT_SET_TYPE (at 0xc311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO04_INT_POLARITY_HIGH"
      sgroup "GPIO04_INT_POLARITY_HIGH (at 0xc312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO04_INT_POLARITY_LOW"
      sgroup "GPIO04_INT_POLARITY_LOW (at 0xc313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO04_INT_LATCHED_CLR"
      sgroup "GPIO04_INT_LATCHED_CLR (at 0xc314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO04_INT_EN_SET"
      sgroup "GPIO04_INT_EN_SET (at 0xc315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO04_INT_EN_CLR"
      sgroup "GPIO04_INT_EN_CLR (at 0xc316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO04_INT_LATCHED_STS"
      sgroup "GPIO04_INT_LATCHED_STS (at 0xc318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO04_INT_PENDING_STS"
      sgroup "GPIO04_INT_PENDING_STS (at 0xc319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO04_INT_MID_SEL"
      sgroup "GPIO04_INT_MID_SEL (at 0xc31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO04_INT_PRIORITY"
      sgroup "GPIO04_INT_PRIORITY (at 0xc31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO04_MODE_CTL"
      sgroup "GPIO04_MODE_CTL (at 0xc340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO04_DIG_VIN_CTL"
      sgroup "GPIO04_DIG_VIN_CTL (at 0xc341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO04_DIG_PULL_CTL"
      sgroup "GPIO04_DIG_PULL_CTL (at 0xc342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO04_DIG_IN_DTEST_SEL"
      sgroup "GPIO04_DIG_IN_DTEST_SEL (at 0xc343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO04_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO04_DIG_OUT_SOURCE_CTL (at 0xc344)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO04_DIG_OUT_DRV_CTL"
      sgroup "GPIO04_DIG_OUT_DRV_CTL (at 0xc345)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO04_EN_CTL"
      sgroup "GPIO04_EN_CTL (at 0xc346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO04_ANA_PASS_THRU_SEL"
      sgroup "GPIO04_ANA_PASS_THRU_SEL (at 0xc34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO04_SEC_ACCESS"
      sgroup "GPIO04_SEC_ACCESS (at 0xc3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO04_PERPH_RESET_CTL1"
      sgroup "GPIO04_PERPH_RESET_CTL1 (at 0xc3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO04_PERPH_RESET_CTL2"
      sgroup "GPIO04_PERPH_RESET_CTL2 (at 0xc3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO04_PERPH_RESET_CTL3"
      sgroup "GPIO04_PERPH_RESET_CTL3 (at 0xc3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO04_PERPH_RESET_CTL4"
      sgroup "GPIO04_PERPH_RESET_CTL4 (at 0xc3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO05"
  tree "GPIO05"
    tree "GPIO05_REVISION1"
      sgroup "GPIO05_REVISION1 (at 0xc400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO05_REVISION2"
      sgroup "GPIO05_REVISION2 (at 0xc401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO05_REVISION3"
      sgroup "GPIO05_REVISION3 (at 0xc402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO05_REVISION4"
      sgroup "GPIO05_REVISION4 (at 0xc403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO05_PERPH_TYPE"
      sgroup "GPIO05_PERPH_TYPE (at 0xc404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO05_PERPH_SUBTYPE"
      sgroup "GPIO05_PERPH_SUBTYPE (at 0xc405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO05_STATUS1"
      sgroup "GPIO05_STATUS1 (at 0xc408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO05_INT_RT_STS"
      sgroup "GPIO05_INT_RT_STS (at 0xc410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO05_INT_SET_TYPE"
      sgroup "GPIO05_INT_SET_TYPE (at 0xc411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO05_INT_POLARITY_HIGH"
      sgroup "GPIO05_INT_POLARITY_HIGH (at 0xc412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO05_INT_POLARITY_LOW"
      sgroup "GPIO05_INT_POLARITY_LOW (at 0xc413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO05_INT_LATCHED_CLR"
      sgroup "GPIO05_INT_LATCHED_CLR (at 0xc414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO05_INT_EN_SET"
      sgroup "GPIO05_INT_EN_SET (at 0xc415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO05_INT_EN_CLR"
      sgroup "GPIO05_INT_EN_CLR (at 0xc416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO05_INT_LATCHED_STS"
      sgroup "GPIO05_INT_LATCHED_STS (at 0xc418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO05_INT_PENDING_STS"
      sgroup "GPIO05_INT_PENDING_STS (at 0xc419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO05_INT_MID_SEL"
      sgroup "GPIO05_INT_MID_SEL (at 0xc41a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO05_INT_PRIORITY"
      sgroup "GPIO05_INT_PRIORITY (at 0xc41b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO05_MODE_CTL"
      sgroup "GPIO05_MODE_CTL (at 0xc440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO05_DIG_VIN_CTL"
      sgroup "GPIO05_DIG_VIN_CTL (at 0xc441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO05_DIG_PULL_CTL"
      sgroup "GPIO05_DIG_PULL_CTL (at 0xc442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO05_DIG_IN_DTEST_SEL"
      sgroup "GPIO05_DIG_IN_DTEST_SEL (at 0xc443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO05_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO05_DIG_OUT_SOURCE_CTL (at 0xc444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO05_DIG_OUT_DRV_CTL"
      sgroup "GPIO05_DIG_OUT_DRV_CTL (at 0xc445)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO05_EN_CTL"
      sgroup "GPIO05_EN_CTL (at 0xc446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO05_ANA_PASS_THRU_SEL"
      sgroup "GPIO05_ANA_PASS_THRU_SEL (at 0xc44a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c44a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc44a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO05_SEC_ACCESS"
      sgroup "GPIO05_SEC_ACCESS (at 0xc4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO05_PERPH_RESET_CTL1"
      sgroup "GPIO05_PERPH_RESET_CTL1 (at 0xc4d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO05_PERPH_RESET_CTL2"
      sgroup "GPIO05_PERPH_RESET_CTL2 (at 0xc4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO05_PERPH_RESET_CTL3"
      sgroup "GPIO05_PERPH_RESET_CTL3 (at 0xc4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO05_PERPH_RESET_CTL4"
      sgroup "GPIO05_PERPH_RESET_CTL4 (at 0xc4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO06"
  tree "GPIO06"
    tree "GPIO06_REVISION1"
      sgroup "GPIO06_REVISION1 (at 0xc500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO06_REVISION2"
      sgroup "GPIO06_REVISION2 (at 0xc501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO06_REVISION3"
      sgroup "GPIO06_REVISION3 (at 0xc502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO06_REVISION4"
      sgroup "GPIO06_REVISION4 (at 0xc503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO06_PERPH_TYPE"
      sgroup "GPIO06_PERPH_TYPE (at 0xc504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO06_PERPH_SUBTYPE"
      sgroup "GPIO06_PERPH_SUBTYPE (at 0xc505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO06_STATUS1"
      sgroup "GPIO06_STATUS1 (at 0xc508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO06_INT_RT_STS"
      sgroup "GPIO06_INT_RT_STS (at 0xc510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO06_INT_SET_TYPE"
      sgroup "GPIO06_INT_SET_TYPE (at 0xc511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO06_INT_POLARITY_HIGH"
      sgroup "GPIO06_INT_POLARITY_HIGH (at 0xc512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO06_INT_POLARITY_LOW"
      sgroup "GPIO06_INT_POLARITY_LOW (at 0xc513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO06_INT_LATCHED_CLR"
      sgroup "GPIO06_INT_LATCHED_CLR (at 0xc514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO06_INT_EN_SET"
      sgroup "GPIO06_INT_EN_SET (at 0xc515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO06_INT_EN_CLR"
      sgroup "GPIO06_INT_EN_CLR (at 0xc516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO06_INT_LATCHED_STS"
      sgroup "GPIO06_INT_LATCHED_STS (at 0xc518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO06_INT_PENDING_STS"
      sgroup "GPIO06_INT_PENDING_STS (at 0xc519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO06_INT_MID_SEL"
      sgroup "GPIO06_INT_MID_SEL (at 0xc51a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO06_INT_PRIORITY"
      sgroup "GPIO06_INT_PRIORITY (at 0xc51b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO06_MODE_CTL"
      sgroup "GPIO06_MODE_CTL (at 0xc540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO06_DIG_VIN_CTL"
      sgroup "GPIO06_DIG_VIN_CTL (at 0xc541)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO06_DIG_PULL_CTL"
      sgroup "GPIO06_DIG_PULL_CTL (at 0xc542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO06_DIG_IN_DTEST_SEL"
      sgroup "GPIO06_DIG_IN_DTEST_SEL (at 0xc543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO06_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO06_DIG_OUT_SOURCE_CTL (at 0xc544)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO06_DIG_OUT_DRV_CTL"
      sgroup "GPIO06_DIG_OUT_DRV_CTL (at 0xc545)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO06_EN_CTL"
      sgroup "GPIO06_EN_CTL (at 0xc546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO06_ANA_PASS_THRU_SEL"
      sgroup "GPIO06_ANA_PASS_THRU_SEL (at 0xc54a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c54a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc54a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO06_SEC_ACCESS"
      sgroup "GPIO06_SEC_ACCESS (at 0xc5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO06_PERPH_RESET_CTL1"
      sgroup "GPIO06_PERPH_RESET_CTL1 (at 0xc5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO06_PERPH_RESET_CTL2"
      sgroup "GPIO06_PERPH_RESET_CTL2 (at 0xc5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO06_PERPH_RESET_CTL3"
      sgroup "GPIO06_PERPH_RESET_CTL3 (at 0xc5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO06_PERPH_RESET_CTL4"
      sgroup "GPIO06_PERPH_RESET_CTL4 (at 0xc5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO07"
  tree "GPIO07"
    tree "GPIO07_REVISION1"
      sgroup "GPIO07_REVISION1 (at 0xc600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO07_REVISION2"
      sgroup "GPIO07_REVISION2 (at 0xc601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO07_REVISION3"
      sgroup "GPIO07_REVISION3 (at 0xc602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO07_REVISION4"
      sgroup "GPIO07_REVISION4 (at 0xc603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO07_PERPH_TYPE"
      sgroup "GPIO07_PERPH_TYPE (at 0xc604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO07_PERPH_SUBTYPE"
      sgroup "GPIO07_PERPH_SUBTYPE (at 0xc605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO07_STATUS1"
      sgroup "GPIO07_STATUS1 (at 0xc608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO07_INT_RT_STS"
      sgroup "GPIO07_INT_RT_STS (at 0xc610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO07_INT_SET_TYPE"
      sgroup "GPIO07_INT_SET_TYPE (at 0xc611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO07_INT_POLARITY_HIGH"
      sgroup "GPIO07_INT_POLARITY_HIGH (at 0xc612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO07_INT_POLARITY_LOW"
      sgroup "GPIO07_INT_POLARITY_LOW (at 0xc613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO07_INT_LATCHED_CLR"
      sgroup "GPIO07_INT_LATCHED_CLR (at 0xc614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO07_INT_EN_SET"
      sgroup "GPIO07_INT_EN_SET (at 0xc615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO07_INT_EN_CLR"
      sgroup "GPIO07_INT_EN_CLR (at 0xc616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO07_INT_LATCHED_STS"
      sgroup "GPIO07_INT_LATCHED_STS (at 0xc618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO07_INT_PENDING_STS"
      sgroup "GPIO07_INT_PENDING_STS (at 0xc619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO07_INT_MID_SEL"
      sgroup "GPIO07_INT_MID_SEL (at 0xc61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c61a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO07_INT_PRIORITY"
      sgroup "GPIO07_INT_PRIORITY (at 0xc61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c61b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO07_MODE_CTL"
      sgroup "GPIO07_MODE_CTL (at 0xc640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO07_DIG_VIN_CTL"
      sgroup "GPIO07_DIG_VIN_CTL (at 0xc641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO07_DIG_PULL_CTL"
      sgroup "GPIO07_DIG_PULL_CTL (at 0xc642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO07_DIG_IN_DTEST_SEL"
      sgroup "GPIO07_DIG_IN_DTEST_SEL (at 0xc643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO07_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO07_DIG_OUT_SOURCE_CTL (at 0xc644)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO07_DIG_OUT_DRV_CTL"
      sgroup "GPIO07_DIG_OUT_DRV_CTL (at 0xc645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO07_EN_CTL"
      sgroup "GPIO07_EN_CTL (at 0xc646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO07_ANA_PASS_THRU_SEL"
      sgroup "GPIO07_ANA_PASS_THRU_SEL (at 0xc64a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c64a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc64a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO07_SEC_ACCESS"
      sgroup "GPIO07_SEC_ACCESS (at 0xc6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO07_PERPH_RESET_CTL1"
      sgroup "GPIO07_PERPH_RESET_CTL1 (at 0xc6d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO07_PERPH_RESET_CTL2"
      sgroup "GPIO07_PERPH_RESET_CTL2 (at 0xc6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO07_PERPH_RESET_CTL3"
      sgroup "GPIO07_PERPH_RESET_CTL3 (at 0xc6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO07_PERPH_RESET_CTL4"
      sgroup "GPIO07_PERPH_RESET_CTL4 (at 0xc6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO08"
  tree "GPIO08"
    tree "GPIO08_REVISION1"
      sgroup "GPIO08_REVISION1 (at 0xc700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO08_REVISION2"
      sgroup "GPIO08_REVISION2 (at 0xc701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO08_REVISION3"
      sgroup "GPIO08_REVISION3 (at 0xc702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO08_REVISION4"
      sgroup "GPIO08_REVISION4 (at 0xc703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO08_PERPH_TYPE"
      sgroup "GPIO08_PERPH_TYPE (at 0xc704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO08_PERPH_SUBTYPE"
      sgroup "GPIO08_PERPH_SUBTYPE (at 0xc705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO08_STATUS1"
      sgroup "GPIO08_STATUS1 (at 0xc708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO08_INT_RT_STS"
      sgroup "GPIO08_INT_RT_STS (at 0xc710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO08_INT_SET_TYPE"
      sgroup "GPIO08_INT_SET_TYPE (at 0xc711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO08_INT_POLARITY_HIGH"
      sgroup "GPIO08_INT_POLARITY_HIGH (at 0xc712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO08_INT_POLARITY_LOW"
      sgroup "GPIO08_INT_POLARITY_LOW (at 0xc713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO08_INT_LATCHED_CLR"
      sgroup "GPIO08_INT_LATCHED_CLR (at 0xc714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO08_INT_EN_SET"
      sgroup "GPIO08_INT_EN_SET (at 0xc715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO08_INT_EN_CLR"
      sgroup "GPIO08_INT_EN_CLR (at 0xc716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO08_INT_LATCHED_STS"
      sgroup "GPIO08_INT_LATCHED_STS (at 0xc718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO08_INT_PENDING_STS"
      sgroup "GPIO08_INT_PENDING_STS (at 0xc719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO08_INT_MID_SEL"
      sgroup "GPIO08_INT_MID_SEL (at 0xc71a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c71a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc71a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO08_INT_PRIORITY"
      sgroup "GPIO08_INT_PRIORITY (at 0xc71b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c71b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc71b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO08_MODE_CTL"
      sgroup "GPIO08_MODE_CTL (at 0xc740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO08_DIG_VIN_CTL"
      sgroup "GPIO08_DIG_VIN_CTL (at 0xc741)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO08_DIG_PULL_CTL"
      sgroup "GPIO08_DIG_PULL_CTL (at 0xc742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO08_DIG_IN_DTEST_SEL"
      sgroup "GPIO08_DIG_IN_DTEST_SEL (at 0xc743)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO08_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO08_DIG_OUT_SOURCE_CTL (at 0xc744)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO08_DIG_OUT_DRV_CTL"
      sgroup "GPIO08_DIG_OUT_DRV_CTL (at 0xc745)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO08_EN_CTL"
      sgroup "GPIO08_EN_CTL (at 0xc746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO08_ANA_PASS_THRU_SEL"
      sgroup "GPIO08_ANA_PASS_THRU_SEL (at 0xc74a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c74a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc74a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO08_SEC_ACCESS"
      sgroup "GPIO08_SEC_ACCESS (at 0xc7d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO08_PERPH_RESET_CTL1"
      sgroup "GPIO08_PERPH_RESET_CTL1 (at 0xc7d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO08_PERPH_RESET_CTL2"
      sgroup "GPIO08_PERPH_RESET_CTL2 (at 0xc7d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO08_PERPH_RESET_CTL3"
      sgroup "GPIO08_PERPH_RESET_CTL3 (at 0xc7da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO08_PERPH_RESET_CTL4"
      sgroup "GPIO08_PERPH_RESET_CTL4 (at 0xc7db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO09"
  tree "GPIO09"
    tree "GPIO09_REVISION1"
      sgroup "GPIO09_REVISION1 (at 0xc800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO09_REVISION2"
      sgroup "GPIO09_REVISION2 (at 0xc801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO09_REVISION3"
      sgroup "GPIO09_REVISION3 (at 0xc802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO09_REVISION4"
      sgroup "GPIO09_REVISION4 (at 0xc803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO09_PERPH_TYPE"
      sgroup "GPIO09_PERPH_TYPE (at 0xc804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO09_PERPH_SUBTYPE"
      sgroup "GPIO09_PERPH_SUBTYPE (at 0xc805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO09_STATUS1"
      sgroup "GPIO09_STATUS1 (at 0xc808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO09_INT_RT_STS"
      sgroup "GPIO09_INT_RT_STS (at 0xc810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO09_INT_SET_TYPE"
      sgroup "GPIO09_INT_SET_TYPE (at 0xc811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO09_INT_POLARITY_HIGH"
      sgroup "GPIO09_INT_POLARITY_HIGH (at 0xc812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO09_INT_POLARITY_LOW"
      sgroup "GPIO09_INT_POLARITY_LOW (at 0xc813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO09_INT_LATCHED_CLR"
      sgroup "GPIO09_INT_LATCHED_CLR (at 0xc814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO09_INT_EN_SET"
      sgroup "GPIO09_INT_EN_SET (at 0xc815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO09_INT_EN_CLR"
      sgroup "GPIO09_INT_EN_CLR (at 0xc816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO09_INT_LATCHED_STS"
      sgroup "GPIO09_INT_LATCHED_STS (at 0xc818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO09_INT_PENDING_STS"
      sgroup "GPIO09_INT_PENDING_STS (at 0xc819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO09_INT_MID_SEL"
      sgroup "GPIO09_INT_MID_SEL (at 0xc81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c81a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO09_INT_PRIORITY"
      sgroup "GPIO09_INT_PRIORITY (at 0xc81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c81b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO09_MODE_CTL"
      sgroup "GPIO09_MODE_CTL (at 0xc840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO09_DIG_VIN_CTL"
      sgroup "GPIO09_DIG_VIN_CTL (at 0xc841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO09_DIG_PULL_CTL"
      sgroup "GPIO09_DIG_PULL_CTL (at 0xc842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO09_DIG_IN_DTEST_SEL"
      sgroup "GPIO09_DIG_IN_DTEST_SEL (at 0xc843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO09_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO09_DIG_OUT_SOURCE_CTL (at 0xc844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO09_DIG_OUT_DRV_CTL"
      sgroup "GPIO09_DIG_OUT_DRV_CTL (at 0xc845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO09_EN_CTL"
      sgroup "GPIO09_EN_CTL (at 0xc846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO09_ANA_PASS_THRU_SEL"
      sgroup "GPIO09_ANA_PASS_THRU_SEL (at 0xc84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c84a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO09_SEC_ACCESS"
      sgroup "GPIO09_SEC_ACCESS (at 0xc8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO09_PERPH_RESET_CTL1"
      sgroup "GPIO09_PERPH_RESET_CTL1 (at 0xc8d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO09_PERPH_RESET_CTL2"
      sgroup "GPIO09_PERPH_RESET_CTL2 (at 0xc8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO09_PERPH_RESET_CTL3"
      sgroup "GPIO09_PERPH_RESET_CTL3 (at 0xc8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO09_PERPH_RESET_CTL4"
      sgroup "GPIO09_PERPH_RESET_CTL4 (at 0xc8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO10"
  tree "GPIO10"
    tree "GPIO10_REVISION1"
      sgroup "GPIO10_REVISION1 (at 0xc900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION2"
      sgroup "GPIO10_REVISION2 (at 0xc901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO10_REVISION3"
      sgroup "GPIO10_REVISION3 (at 0xc902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION4"
      sgroup "GPIO10_REVISION4 (at 0xc903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO10_PERPH_TYPE"
      sgroup "GPIO10_PERPH_TYPE (at 0xc904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO10_PERPH_SUBTYPE"
      sgroup "GPIO10_PERPH_SUBTYPE (at 0xc905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO10_STATUS1"
      sgroup "GPIO10_STATUS1 (at 0xc908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO10_INT_RT_STS"
      sgroup "GPIO10_INT_RT_STS (at 0xc910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO10_INT_SET_TYPE"
      sgroup "GPIO10_INT_SET_TYPE (at 0xc911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO10_INT_POLARITY_HIGH"
      sgroup "GPIO10_INT_POLARITY_HIGH (at 0xc912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_POLARITY_LOW"
      sgroup "GPIO10_INT_POLARITY_LOW (at 0xc913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_CLR"
      sgroup "GPIO10_INT_LATCHED_CLR (at 0xc914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO10_INT_EN_SET"
      sgroup "GPIO10_INT_EN_SET (at 0xc915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_EN_CLR"
      sgroup "GPIO10_INT_EN_CLR (at 0xc916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_STS"
      sgroup "GPIO10_INT_LATCHED_STS (at 0xc918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO10_INT_PENDING_STS"
      sgroup "GPIO10_INT_PENDING_STS (at 0xc919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO10_INT_MID_SEL"
      sgroup "GPIO10_INT_MID_SEL (at 0xc91a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c91a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc91a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO10_INT_PRIORITY"
      sgroup "GPIO10_INT_PRIORITY (at 0xc91b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c91b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc91b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO10_MODE_CTL"
      sgroup "GPIO10_MODE_CTL (at 0xc940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO10_DIG_VIN_CTL"
      sgroup "GPIO10_DIG_VIN_CTL (at 0xc941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO10_DIG_PULL_CTL"
      sgroup "GPIO10_DIG_PULL_CTL (at 0xc942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO10_DIG_IN_DTEST_SEL"
      sgroup "GPIO10_DIG_IN_DTEST_SEL (at 0xc943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO10_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO10_DIG_OUT_SOURCE_CTL (at 0xc944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO10_DIG_OUT_DRV_CTL"
      sgroup "GPIO10_DIG_OUT_DRV_CTL (at 0xc945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO10_EN_CTL"
      sgroup "GPIO10_EN_CTL (at 0xc946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO10_ANA_PASS_THRU_SEL"
      sgroup "GPIO10_ANA_PASS_THRU_SEL (at 0xc94a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c94a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO10_SEC_ACCESS"
      sgroup "GPIO10_SEC_ACCESS (at 0xc9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO10_PERPH_RESET_CTL1"
      sgroup "GPIO10_PERPH_RESET_CTL1 (at 0xc9d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL2"
      sgroup "GPIO10_PERPH_RESET_CTL2 (at 0xc9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL3"
      sgroup "GPIO10_PERPH_RESET_CTL3 (at 0xc9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL4"
      sgroup "GPIO10_PERPH_RESET_CTL4 (at 0xc9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO11"
  tree "GPIO11"
    tree "GPIO11_REVISION1"
      sgroup "GPIO11_REVISION1 (at 0xca00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO11_REVISION2"
      sgroup "GPIO11_REVISION2 (at 0xca01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO11_REVISION3"
      sgroup "GPIO11_REVISION3 (at 0xca02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO11_REVISION4"
      sgroup "GPIO11_REVISION4 (at 0xca03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO11_PERPH_TYPE"
      sgroup "GPIO11_PERPH_TYPE (at 0xca04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO11_PERPH_SUBTYPE"
      sgroup "GPIO11_PERPH_SUBTYPE (at 0xca05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO11_STATUS1"
      sgroup "GPIO11_STATUS1 (at 0xca08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO11_INT_RT_STS"
      sgroup "GPIO11_INT_RT_STS (at 0xca10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO11_INT_SET_TYPE"
      sgroup "GPIO11_INT_SET_TYPE (at 0xca11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO11_INT_POLARITY_HIGH"
      sgroup "GPIO11_INT_POLARITY_HIGH (at 0xca12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO11_INT_POLARITY_LOW"
      sgroup "GPIO11_INT_POLARITY_LOW (at 0xca13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO11_INT_LATCHED_CLR"
      sgroup "GPIO11_INT_LATCHED_CLR (at 0xca14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO11_INT_EN_SET"
      sgroup "GPIO11_INT_EN_SET (at 0xca15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO11_INT_EN_CLR"
      sgroup "GPIO11_INT_EN_CLR (at 0xca16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO11_INT_LATCHED_STS"
      sgroup "GPIO11_INT_LATCHED_STS (at 0xca18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO11_INT_PENDING_STS"
      sgroup "GPIO11_INT_PENDING_STS (at 0xca19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO11_INT_MID_SEL"
      sgroup "GPIO11_INT_MID_SEL (at 0xca1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO11_INT_PRIORITY"
      sgroup "GPIO11_INT_PRIORITY (at 0xca1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO11_MODE_CTL"
      sgroup "GPIO11_MODE_CTL (at 0xca40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO11_DIG_VIN_CTL"
      sgroup "GPIO11_DIG_VIN_CTL (at 0xca41)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO11_DIG_PULL_CTL"
      sgroup "GPIO11_DIG_PULL_CTL (at 0xca42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO11_DIG_IN_DTEST_SEL"
      sgroup "GPIO11_DIG_IN_DTEST_SEL (at 0xca43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO11_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO11_DIG_OUT_SOURCE_CTL (at 0xca44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO11_DIG_OUT_DRV_CTL"
      sgroup "GPIO11_DIG_OUT_DRV_CTL (at 0xca45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO11_EN_CTL"
      sgroup "GPIO11_EN_CTL (at 0xca46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO11_ANA_PASS_THRU_SEL"
      sgroup "GPIO11_ANA_PASS_THRU_SEL (at 0xca4a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO11_SEC_ACCESS"
      sgroup "GPIO11_SEC_ACCESS (at 0xcad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO11_PERPH_RESET_CTL1"
      sgroup "GPIO11_PERPH_RESET_CTL1 (at 0xcad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL2"
      sgroup "GPIO11_PERPH_RESET_CTL2 (at 0xcad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL3"
      sgroup "GPIO11_PERPH_RESET_CTL3 (at 0xcada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL4"
      sgroup "GPIO11_PERPH_RESET_CTL4 (at 0xcadb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cadb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO12"
  tree "GPIO12"
    tree "GPIO12_REVISION1"
      sgroup "GPIO12_REVISION1 (at 0xcb00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO12_REVISION2"
      sgroup "GPIO12_REVISION2 (at 0xcb01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO12_REVISION3"
      sgroup "GPIO12_REVISION3 (at 0xcb02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO12_REVISION4"
      sgroup "GPIO12_REVISION4 (at 0xcb03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO12_PERPH_TYPE"
      sgroup "GPIO12_PERPH_TYPE (at 0xcb04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO12_PERPH_SUBTYPE"
      sgroup "GPIO12_PERPH_SUBTYPE (at 0xcb05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO12_STATUS1"
      sgroup "GPIO12_STATUS1 (at 0xcb08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO12_INT_RT_STS"
      sgroup "GPIO12_INT_RT_STS (at 0xcb10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO12_INT_SET_TYPE"
      sgroup "GPIO12_INT_SET_TYPE (at 0xcb11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO12_INT_POLARITY_HIGH"
      sgroup "GPIO12_INT_POLARITY_HIGH (at 0xcb12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO12_INT_POLARITY_LOW"
      sgroup "GPIO12_INT_POLARITY_LOW (at 0xcb13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO12_INT_LATCHED_CLR"
      sgroup "GPIO12_INT_LATCHED_CLR (at 0xcb14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO12_INT_EN_SET"
      sgroup "GPIO12_INT_EN_SET (at 0xcb15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO12_INT_EN_CLR"
      sgroup "GPIO12_INT_EN_CLR (at 0xcb16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO12_INT_LATCHED_STS"
      sgroup "GPIO12_INT_LATCHED_STS (at 0xcb18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO12_INT_PENDING_STS"
      sgroup "GPIO12_INT_PENDING_STS (at 0xcb19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO12_INT_MID_SEL"
      sgroup "GPIO12_INT_MID_SEL (at 0xcb1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO12_INT_PRIORITY"
      sgroup "GPIO12_INT_PRIORITY (at 0xcb1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO12_MODE_CTL"
      sgroup "GPIO12_MODE_CTL (at 0xcb40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO12_DIG_VIN_CTL"
      sgroup "GPIO12_DIG_VIN_CTL (at 0xcb41)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO12_DIG_PULL_CTL"
      sgroup "GPIO12_DIG_PULL_CTL (at 0xcb42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO12_DIG_IN_DTEST_SEL"
      sgroup "GPIO12_DIG_IN_DTEST_SEL (at 0xcb43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO12_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO12_DIG_OUT_SOURCE_CTL (at 0xcb44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO12_DIG_OUT_DRV_CTL"
      sgroup "GPIO12_DIG_OUT_DRV_CTL (at 0xcb45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO12_EN_CTL"
      sgroup "GPIO12_EN_CTL (at 0xcb46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO12_ANA_PASS_THRU_SEL"
      sgroup "GPIO12_ANA_PASS_THRU_SEL (at 0xcb4a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO12_SEC_ACCESS"
      sgroup "GPIO12_SEC_ACCESS (at 0xcbd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO12_PERPH_RESET_CTL1"
      sgroup "GPIO12_PERPH_RESET_CTL1 (at 0xcbd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL2"
      sgroup "GPIO12_PERPH_RESET_CTL2 (at 0xcbd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL3"
      sgroup "GPIO12_PERPH_RESET_CTL3 (at 0xcbda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL4"
      sgroup "GPIO12_PERPH_RESET_CTL4 (at 0xcbdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO13"
  tree "GPIO13"
    tree "GPIO13_REVISION1"
      sgroup "GPIO13_REVISION1 (at 0xcc00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO13_REVISION2"
      sgroup "GPIO13_REVISION2 (at 0xcc01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO13_REVISION3"
      sgroup "GPIO13_REVISION3 (at 0xcc02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO13_REVISION4"
      sgroup "GPIO13_REVISION4 (at 0xcc03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO13_PERPH_TYPE"
      sgroup "GPIO13_PERPH_TYPE (at 0xcc04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO13_PERPH_SUBTYPE"
      sgroup "GPIO13_PERPH_SUBTYPE (at 0xcc05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO13_STATUS1"
      sgroup "GPIO13_STATUS1 (at 0xcc08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO13_INT_RT_STS"
      sgroup "GPIO13_INT_RT_STS (at 0xcc10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO13_INT_SET_TYPE"
      sgroup "GPIO13_INT_SET_TYPE (at 0xcc11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO13_INT_POLARITY_HIGH"
      sgroup "GPIO13_INT_POLARITY_HIGH (at 0xcc12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO13_INT_POLARITY_LOW"
      sgroup "GPIO13_INT_POLARITY_LOW (at 0xcc13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO13_INT_LATCHED_CLR"
      sgroup "GPIO13_INT_LATCHED_CLR (at 0xcc14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO13_INT_EN_SET"
      sgroup "GPIO13_INT_EN_SET (at 0xcc15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO13_INT_EN_CLR"
      sgroup "GPIO13_INT_EN_CLR (at 0xcc16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO13_INT_LATCHED_STS"
      sgroup "GPIO13_INT_LATCHED_STS (at 0xcc18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO13_INT_PENDING_STS"
      sgroup "GPIO13_INT_PENDING_STS (at 0xcc19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO13_INT_MID_SEL"
      sgroup "GPIO13_INT_MID_SEL (at 0xcc1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO13_INT_PRIORITY"
      sgroup "GPIO13_INT_PRIORITY (at 0xcc1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO13_MODE_CTL"
      sgroup "GPIO13_MODE_CTL (at 0xcc40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO13_DIG_VIN_CTL"
      sgroup "GPIO13_DIG_VIN_CTL (at 0xcc41)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO13_DIG_PULL_CTL"
      sgroup "GPIO13_DIG_PULL_CTL (at 0xcc42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO13_DIG_IN_DTEST_SEL"
      sgroup "GPIO13_DIG_IN_DTEST_SEL (at 0xcc43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO13_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO13_DIG_OUT_SOURCE_CTL (at 0xcc44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO13_DIG_OUT_DRV_CTL"
      sgroup "GPIO13_DIG_OUT_DRV_CTL (at 0xcc45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO13_EN_CTL"
      sgroup "GPIO13_EN_CTL (at 0xcc46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO13_ANA_PASS_THRU_SEL"
      sgroup "GPIO13_ANA_PASS_THRU_SEL (at 0xcc4a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80cc4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcc4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO13_SEC_ACCESS"
      sgroup "GPIO13_SEC_ACCESS (at 0xccd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80ccd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xccd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO13_PERPH_RESET_CTL1"
      sgroup "GPIO13_PERPH_RESET_CTL1 (at 0xccd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80ccd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xccd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO13_PERPH_RESET_CTL2"
      sgroup "GPIO13_PERPH_RESET_CTL2 (at 0xccd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80ccd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xccd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO13_PERPH_RESET_CTL3"
      sgroup "GPIO13_PERPH_RESET_CTL3 (at 0xccda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80ccda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xccda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO13_PERPH_RESET_CTL4"
      sgroup "GPIO13_PERPH_RESET_CTL4 (at 0xccdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        set &access:&cmd_addr %l 0x80ccdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xccdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO14"
  tree "GPIO14"
    tree "GPIO14_REVISION1"
      sgroup "GPIO14_REVISION1 (at 0xcd00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO14_REVISION2"
      sgroup "GPIO14_REVISION2 (at 0xcd01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO14_REVISION3"
      sgroup "GPIO14_REVISION3 (at 0xcd02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO14_REVISION4"
      sgroup "GPIO14_REVISION4 (at 0xcd03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO14_PERPH_TYPE"
      sgroup "GPIO14_PERPH_TYPE (at 0xcd04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO14_PERPH_SUBTYPE"
      sgroup "GPIO14_PERPH_SUBTYPE (at 0xcd05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO14_STATUS1"
      sgroup "GPIO14_STATUS1 (at 0xcd08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO14_INT_RT_STS"
      sgroup "GPIO14_INT_RT_STS (at 0xcd10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO14_INT_SET_TYPE"
      sgroup "GPIO14_INT_SET_TYPE (at 0xcd11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO14_INT_POLARITY_HIGH"
      sgroup "GPIO14_INT_POLARITY_HIGH (at 0xcd12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO14_INT_POLARITY_LOW"
      sgroup "GPIO14_INT_POLARITY_LOW (at 0xcd13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO14_INT_LATCHED_CLR"
      sgroup "GPIO14_INT_LATCHED_CLR (at 0xcd14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO14_INT_EN_SET"
      sgroup "GPIO14_INT_EN_SET (at 0xcd15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO14_INT_EN_CLR"
      sgroup "GPIO14_INT_EN_CLR (at 0xcd16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO14_INT_LATCHED_STS"
      sgroup "GPIO14_INT_LATCHED_STS (at 0xcd18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO14_INT_PENDING_STS"
      sgroup "GPIO14_INT_PENDING_STS (at 0xcd19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO14_INT_MID_SEL"
      sgroup "GPIO14_INT_MID_SEL (at 0xcd1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO14_INT_PRIORITY"
      sgroup "GPIO14_INT_PRIORITY (at 0xcd1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO14_MODE_CTL"
      sgroup "GPIO14_MODE_CTL (at 0xcd40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO14_DIG_VIN_CTL"
      sgroup "GPIO14_DIG_VIN_CTL (at 0xcd41)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO14_DIG_PULL_CTL"
      sgroup "GPIO14_DIG_PULL_CTL (at 0xcd42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO14_DIG_IN_DTEST_SEL"
      sgroup "GPIO14_DIG_IN_DTEST_SEL (at 0xcd43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO14_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO14_DIG_OUT_SOURCE_CTL (at 0xcd44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO14_DIG_OUT_DRV_CTL"
      sgroup "GPIO14_DIG_OUT_DRV_CTL (at 0xcd45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO14_EN_CTL"
      sgroup "GPIO14_EN_CTL (at 0xcd46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO14_ANA_PASS_THRU_SEL"
      sgroup "GPIO14_ANA_PASS_THRU_SEL (at 0xcd4a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cd4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO14_SEC_ACCESS"
      sgroup "GPIO14_SEC_ACCESS (at 0xcdd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cdd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcdd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO14_PERPH_RESET_CTL1"
      sgroup "GPIO14_PERPH_RESET_CTL1 (at 0xcdd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cdd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcdd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO14_PERPH_RESET_CTL2"
      sgroup "GPIO14_PERPH_RESET_CTL2 (at 0xcdd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cdd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcdd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO14_PERPH_RESET_CTL3"
      sgroup "GPIO14_PERPH_RESET_CTL3 (at 0xcdda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cdda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcdda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO14_PERPH_RESET_CTL4"
      sgroup "GPIO14_PERPH_RESET_CTL4 (at 0xcddb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        set &access:&cmd_addr %l 0x80cddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "HAPTICS"
  tree "HAPTICS"
    tree "HAPTICS_REVISION1"
      sgroup "HAPTICS_REVISION1 (at 0x1c000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "HAPTICS_REVISION2"
      sgroup "HAPTICS_REVISION2 (at 0x1c001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "HAPTICS_REVISION3"
      sgroup "HAPTICS_REVISION3 (at 0x1c002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "HAPTICS_REVISION4"
      sgroup "HAPTICS_REVISION4 (at 0x1c003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "HAPTICS_PERPH_TYPE"
      sgroup "HAPTICS_PERPH_TYPE (at 0x1c004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "HAPTICS_PERPH_SUBTYPE"
      sgroup "HAPTICS_PERPH_SUBTYPE (at 0x1c005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "HAPTICS_STATUS_1"
      sgroup "HAPTICS_STATUS_1 (at 0x1c00a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c00a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc00a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_STS                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AUTO_RES_ERROR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SC_FLAG                                  = " "0 (NO_SC),1 (SC_DET)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OC_FLAG                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BUSY                                     = " "0 (IDLE),1 (BUSY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PLAY_STS                                 = " "0, 1"
    tree.end
    tree "HAPTICS_LRA_AUTO_RES_LO"
      sgroup "HAPTICS_LRA_AUTO_RES_LO (at 0x1c00b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c00b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc00b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PERIOD                                   = "
    tree.end
    tree "HAPTICS_LRA_AUTO_RES_HI"
      sgroup "HAPTICS_LRA_AUTO_RES_HI (at 0x1c00c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c00c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc00c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PERIOD                                   = "
    tree.end
    tree "HAPTICS_INT_RT_STS"
      sgroup "HAPTICS_INT_RT_STS (at 0x1c010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_RT_STS                            = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "HAPTICS_INT_SET_TYPE"
      sgroup "HAPTICS_INT_SET_TYPE (at 0x1c011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_SET_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_SET_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "HAPTICS_INT_POLARITY_HIGH"
      sgroup "HAPTICS_INT_POLARITY_HIGH (at 0x1c012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_POLARITY_HIGH                   = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_POLARITY_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "HAPTICS_INT_POLARITY_LOW"
      sgroup "HAPTICS_INT_POLARITY_LOW (at 0x1c013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_POLARITY_LOW                    = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_POLARITY_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "HAPTICS_INT_LATCHED_CLR"
      sgroup "HAPTICS_INT_LATCHED_CLR (at 0x1c014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_LATCHED_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_LATCHED_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "HAPTICS_INT_EN_SET"
      sgroup "HAPTICS_INT_EN_SET (at 0x1c015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_EN_SET                          = " "0 (reserved),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_EN_SET                            = " "0 (reserved),1 (INT_ENABLED)"
    tree.end
    tree "HAPTICS_INT_EN_CLR"
      sgroup "HAPTICS_INT_EN_CLR (at 0x1c016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_EN_CLR                          = " "0 (reserved),1 (INT_DISABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_EN_CLR                            = " "0 (reserved),1 (INT_DISABLED)"
    tree.end
    tree "HAPTICS_INT_LATCHED_STS"
      sgroup "HAPTICS_INT_LATCHED_STS (at 0x1c018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_LATCHED_STS                       = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "HAPTICS_INT_PENDING_STS"
      sgroup "HAPTICS_INT_PENDING_STS (at 0x1c019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_PENDING_STS                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "HAPTICS_INT_MID_SEL"
      sgroup "HAPTICS_INT_MID_SEL (at 0x1c01a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "HAPTICS_INT_PRIORITY"
      sgroup "HAPTICS_INT_PRIORITY (at 0x1c01b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "HAPTICS_EN_CTL1"
      sgroup "HAPTICS_EN_CTL1 (at 0x1c046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HAPTICS_EN                               = " "0 (HAPTICS_DIS),1 (HAPTICS_EN)"
    tree.end
    tree "HAPTICS_EN_CTL2"
      sgroup "HAPTICS_EN_CTL2 (at 0x1c048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DERATE_OTST2_EN                          = " "0 (DERATE_OTST2_DIS),1 (DERATE_OTST2_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DERATE_HIGH_IBAT_EN                      = " "0 (DERATE_HIGH_IBAT_DIS),1 (DERATE_HIGH_IBAT_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DERATE_HIGH_TEMP_EN                      = " "0 (DERATE_HIGH_TEMP_DIS),1 (DERATE_HIGH_TEMP_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DERATE_LOW_VBAT_EN                       = " "0 (DERATE_LOW_VBAT_DIS),1 (DERATE_LOW_VBAT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BRAKE_EN                                 = " "0 (BRAKING_DIS),1 (BRAKING_EN)"
    tree.end
    tree "HAPTICS_EN_CTL3"
      sgroup "HAPTICS_EN_CTL3 (at 0x1c04a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HBRIDGE_EN                               = " "0 (HIGH_Z),1 (HBRIDGE_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PWM_SIGNAL_EN                            = " "0 (PWM_ZERO),1 (PWM_SIGNAL_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIM_EN                                  = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILIM_CC_EN                               = " "0 (CC_DIS),1 (CC_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AUTO_RES_RBIAS_EN                        = " "0 (RBIAS_DIS),1 (RBIAS_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DAC_EN                                   = " "0 (DAC_DIS),1 (DAC_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ZX_HYST_EN                               = " "0 (ZX_HYST_DIS),1 (ZX_HYST_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_CTL_EN                               = " "0 (PWM_DIS),1 (PWM_CTL_EN)"
    tree.end
    tree "HAPTICS_CFG1"
      sgroup "HAPTICS_CFG1 (at 0x1c04c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ACTUATOR_TYPE                            = " "0 (LRA),1 (ERM)"
    tree.end
    tree "HAPTICS_CFG2"
      sgroup "HAPTICS_CFG2 (at 0x1c04d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LRA_RES_TYPE                             = " "0 (SINUSOID),1 (SQUARE)"
    tree.end
    tree "HAPTICS_SEL"
      sgroup "HAPTICS_SEL (at 0x1c04e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   WF_SOURCE                                = " "0 (VMAX),1 (BUFFER),2 (AUDIO),3 (EXT_PWM)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER                                  = " "0 (HAPTICS_PLAY),1 (LINE_IN)"
    tree.end
    tree "HAPTICS_AUTO_RES_CFG"
      sgroup "HAPTICS_AUTO_RES_CFG (at 0x1c04f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   LRA_AUTO_RES_MODE                        = " "0 (NO_AUTO_RES),1 (ZXD),2 (QWD),3 (MAX_QWD),4 (ZXD_EOP),5 (reserved),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   LRA_HIGH_Z                               = " "0 (NO_HIGHZ),1 (HIGHZ_OPT1),2 (HIGHZ_OPT2),3 (HIGHZ_OPT3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LRA_RES_CALIB                            = " "0 (FOUR_PERIODS),1 (EIGHT_PERIODS),2 (SIXTEEN_PERIODS),3 (THIRTYTWO_PERIODS)"
    tree.end
    tree "HAPTICS_SLEW_CFG"
      sgroup "HAPTICS_SLEW_CFG (at 0x1c050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SLEW_RATE                                = " "0 (SLEW_6NS),1 (SLEW_16NS)"
    tree.end
    tree "HAPTICS_VMAX_CFG"
      sgroup "HAPTICS_VMAX_CFG (at 0x1c051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VMAX                                     = "
    tree.end
    tree "HAPTICS_ILIM_CFG"
      sgroup "HAPTICS_ILIM_CFG (at 0x1c052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ILIM_SEL                                 = " "0 (ILIM_400MA),1 (ILIM_800MA)"
    tree.end
    tree "HAPTICS_SC_DEB_CFG"
      sgroup "HAPTICS_SC_DEB_CFG (at 0x1c053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SC_DEB                                   = " "0 (NO_DEB),1 (DEB_8CLK),2 (DEB_16CLK),3 (DEB_32CLK),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "HAPTICS_RATE_CFG1"
      sgroup "HAPTICS_RATE_CFG1 (at 0x1c054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RATE_7_0                                 = "
    tree.end
    tree "HAPTICS_RATE_CFG2"
      sgroup "HAPTICS_RATE_CFG2 (at 0x1c055)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RATE_11_8                                = "
    tree.end
    tree "HAPTICS_INTERNAL_PWM"
      sgroup "HAPTICS_INTERNAL_PWM (at 0x1c056)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FREQ_SEL                                 = " "0 (PWM_253KHZ),1 (PWM_505KHZ),2 (PWM_739KHZ),3 (PWM_1076KHZ)"
    tree.end
    tree "HAPTICS_EXTERNAL_PWM"
      sgroup "HAPTICS_EXTERNAL_PWM (at 0x1c057)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FREQ_SEL                                 = " "0 (EXT_PWM_25KHZ),1 (EXT_PWM_50KHZ),2 (EXT_PWM_75KHZ),3 (EXT_PWM_100KHZ)"
    tree.end
    tree "HAPTICS_PWM"
      sgroup "HAPTICS_PWM (at 0x1c058)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CAP_SEL                                  = " "0 (PWM_CAP_26PF),1 (PWM_CAP_13PF),2 (PWM_CAP_8P7PF),3 (PWM_CAP_6P5PF)"
    tree.end
    tree "HAPTICS_SC_CLR"
      sgroup "HAPTICS_SC_CLR (at 0x1c059)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_CLR                                   = " "0 (SC_DIS),1 (SC_CLR)"
    tree.end
    tree "HAPTICS_BRAKE"
      sgroup "HAPTICS_BRAKE (at 0x1c05c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c05c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc05c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   PATTERN4                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PATTERN3                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PATTERN2                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PATTERN1                                 = " "0 (ZERO),1 (VMAX_DIV4),2 (VMAX_DIV2),3 (VMAX)"
    tree.end
    tree "HAPTICS_WF_REPEAT"
      sgroup "HAPTICS_WF_REPEAT (at 0x1c05e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c05e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc05e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   WF_REPEAT                                = " "0 (WF_REPEAT_1_TIMES),1 (WF_REPEAT_2_TIMES),2 (WF_REPEAT_4_TIMES),3 (WF_REPEAT_8_TIMES),4 (WF_REPEAT_16_TIMES),5 (WF_REPEAT_32_TIMES),6 (WF_REPEAT_64_TIMES),7 (WF_REPEAT_128_TIMES)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   WF_REPEAT_RSVD                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   WF_S_REPEAT                              = " "0 (WF_S_REPEAT_1_TIMES),1 (WF_S_REPEAT_2_TIMES),2 (WF_S_REPEAT_4_TIMES),3 (WF_S_REPEAT_8_TIMES)"
    tree.end
    tree "HAPTICS_WF_S1"
      sgroup "HAPTICS_WF_S1 (at 0x1c060)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S2"
      sgroup "HAPTICS_WF_S2 (at 0x1c061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S3"
      sgroup "HAPTICS_WF_S3 (at 0x1c062)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S4"
      sgroup "HAPTICS_WF_S4 (at 0x1c063)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S5"
      sgroup "HAPTICS_WF_S5 (at 0x1c064)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S6"
      sgroup "HAPTICS_WF_S6 (at 0x1c065)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S7"
      sgroup "HAPTICS_WF_S7 (at 0x1c066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_WF_S8"
      sgroup "HAPTICS_WF_S8 (at 0x1c067)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SIGN                                     = " "0 (FORWARD),1 (REVERSE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVD                                      = " "0 (OVD_1X),1 (OVD_2X)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   AMP                                      = "
    tree.end
    tree "HAPTICS_PLAY"
      sgroup "HAPTICS_PLAY (at 0x1c070)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PLAY                                     = " "0 (STOP),1 (PLAY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PAUSE                                    = " "0 (CONTINUE),1 (PAUSE)"
    tree.end
    tree "HAPTICS_SEC_ACCESS"
      sgroup "HAPTICS_SEC_ACCESS (at 0x1c0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL2"
      sgroup "HAPTICS_PERPH_RESET_CTL2 (at 0x1c0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL3"
      sgroup "HAPTICS_PERPH_RESET_CTL3 (at 0x1c0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (IGNORE),1 (FOLLOW)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (IGNORE),1 (FOLLOW)"
    tree.end
    tree "HAPTICS_PERPH_RESET_CTL4"
      sgroup "HAPTICS_PERPH_RESET_CTL4 (at 0x1c0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "HAPTICS_SPARE"
      sgroup "HAPTICS_SPARE (at 0x1c0df)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "HAPTICS_INT_TEST1"
      sgroup "HAPTICS_INT_TEST1 (at 0x1c0e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "HAPTICS_INT_TEST_VAL"
      sgroup "HAPTICS_INT_TEST_VAL (at 0x1c0e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PLAY_INT_VAL                             = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SC_INT_VAL                               = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "HAPTICS_TEST1"
      sgroup "HAPTICS_TEST1 (at 0x1c0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST_SEL                                = "
    tree.end
    tree "HAPTICS_TEST2"
      sgroup "HAPTICS_TEST2 (at 0x1c0e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AUTO_RES_EN                              = " "0 (AUTO_RES_DIS),1 (AUTO_RES_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   EXT_PWM_DTEST_SEL                        = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "HAPTICS_TEST3"
      sgroup "HAPTICS_TEST3 (at 0x1c0e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_ILIM_100MA                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_HI_Z                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_PFET_P_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TM_NFET_P_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TM_PFET_M_ON                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_NFET_M_ON                             = " "0, 1"
    tree.end
    tree "HAPTICS_TRIM_NUM"
      sgroup "HAPTICS_TRIM_NUM (at 0x1c0f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "HAPTICS_REF_BUFF_TRIM"
      sgroup "HAPTICS_REF_BUFF_TRIM (at 0x1c0f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DIS_TRIM),1 (EN_TRIM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CALIB                                    = " "0 (DIS_CAL),1 (EN_CAL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CODE                                     = "
    tree.end
    tree "HAPTICS_ERR_AMP_TRIM"
      sgroup "HAPTICS_ERR_AMP_TRIM (at 0x1c0f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN                                       = " "0 (DIS_TRIM),1 (EN_TRIM)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CALIB                                    = " "0 (DIS_CAL),1 (EN_CAL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CODE                                     = "
    tree.end
  tree.end
tree.end
tree "IBB"
  tree "IBB"
    tree "IBB_REVISION1"
      sgroup "IBB_REVISION1 (at 0x1dc00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "IBB_REVISION2"
      sgroup "IBB_REVISION2 (at 0x1dc01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "IBB_REVISION3"
      sgroup "IBB_REVISION3 (at 0x1dc02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "IBB_REVISION4"
      sgroup "IBB_REVISION4 (at 0x1dc03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "IBB_PERPH_TYPE"
      sgroup "IBB_PERPH_TYPE (at 0x1dc04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "IBB_PERPH_SUBTYPE"
      sgroup "IBB_PERPH_SUBTYPE (at 0x1dc05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "IBB_STATUS1"
      sgroup "IBB_STATUS1 (at 0x1dc08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0 (VREG_NOTOK),1 (VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SC_DETECT                                = " "0 (MODULE_NO_SC_FAULT),1 (MODULE_SHORT_CIRCUIT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILIMIT_ERROR                             = " "0 (NO_ILIMIT_ERROR),1 (ILIMIT_ERROR)"
    tree.end
    tree "IBB_STATUS2"
      sgroup "IBB_STATUS2 (at 0x1dc09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CURRENT_OUTPUT_VOLTAGE                   = "
    tree.end
    tree "IBB_STATUS3"
      sgroup "IBB_STATUS3 (at 0x1dc0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IBB_STATUS                               = "
    tree.end
    tree "IBB_STATUS4"
      sgroup "IBB_STATUS4 (at 0x1dc0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_WLED_AVDD_SWIRE                  = "
    tree.end
    tree "IBB_INT_RT_STS"
      sgroup "IBB_INT_RT_STS (at 0x1dc10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_RT_STS                    = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_RT_STS                          = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_RT_STS                      = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_RT_STS                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "IBB_INT_SET_TYPE"
      sgroup "IBB_INT_SET_TYPE (at 0x1dc11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_TYPE                      = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_TYPE                            = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TYPE                        = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "IBB_INT_POLARITY_HIGH"
      sgroup "IBB_INT_POLARITY_HIGH (at 0x1dc12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_HIGH                      = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_HIGH                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_HIGH                        = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "IBB_INT_POLARITY_LOW"
      sgroup "IBB_INT_POLARITY_LOW (at 0x1dc13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_LOW                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LOW                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LOW                         = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "IBB_INT_LATCHED_CLR"
      sgroup "IBB_INT_LATCHED_CLR (at 0x1dc14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_LATCHED_CLR               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "IBB_INT_EN_SET"
      sgroup "IBB_INT_EN_SET (at 0x1dc15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_EN_SET                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_EN_SET                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_SET                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "IBB_INT_EN_CLR"
      sgroup "IBB_INT_EN_CLR (at 0x1dc16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_EN_CLR                    = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_EN_CLR                          = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_EN_CLR                      = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "IBB_INT_LATCHED_STS"
      sgroup "IBB_INT_LATCHED_STS (at 0x1dc18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_LATCHED_STS               = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_LATCHED_STS                     = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_LATCHED_STS                 = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "IBB_INT_PENDING_STS"
      sgroup "IBB_INT_PENDING_STS (at 0x1dc19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_PENDING_STS               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_PENDING_STS                     = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_PENDING_STS                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "IBB_INT_MID_SEL"
      sgroup "IBB_INT_MID_SEL (at 0x1dc1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "IBB_INT_PRIORITY"
      sgroup "IBB_INT_PRIORITY (at 0x1dc1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "IBB_OUTPUT_VOLTAGE"
      sgroup "IBB_OUTPUT_VOLTAGE (at 0x1dc41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVERRIDE_OUTPUT_VOLTAGE                  = " "0 (DEFAULT_OUTPUT_VOLTAGE),1 (OVERRIDE_OUTPUT_VOLTAGE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE                       = "
    tree.end
    tree "IBB_RING_SUPPRESSION_CTL"
      sgroup "IBB_RING_SUPPRESSION_CTL (at 0x1dc42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RING_SUPPRESSION                  = " "0 (RING_SUPPRESSION_DISABLED),1 (RING_SUPPRESSION_ENABLED)"
    tree.end
    tree "IBB_LCD_AMOLED_SEL"
      sgroup "IBB_LCD_AMOLED_SEL (at 0x1dc44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LCD_AMOLED_SELECT                        = " "0 (LCD_MODE),1 (AMOLED_MODE)"
    tree.end
    tree "IBB_MODULE_RDY"
      sgroup "IBB_MODULE_RDY (at 0x1dc45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_RDY                               = " "0 (IBB_NOT_RDY),1 (IBB_RDY)"
    tree.end
    tree "IBB_ENABLE_CTL"
      sgroup "IBB_ENABLE_CTL (at 0x1dc46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_EN                                = " "0 (MODULE_DIS),1 (MODULE_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SWIRE_RDY                                = " "0 (SWIRE_NOT_RDY),1 (SWIRE_RDY)"
    tree.end
    tree "IBB_PD_CTL"
      sgroup "IBB_PD_CTL (at 0x1dc47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_PD                                = " "0 (PD_DISABLE),1 (PD_ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PD_STRENGTH                              = " "0 (PD_FULLSTRENGTH),1 (PD_HALFSTRENGTH)"
    tree.end
    tree "IBB_CLK_DIV"
      sgroup "IBB_CLK_DIV (at 0x1dc48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "IBB_IPLIMIT_STARTUP_CTL_1"
      sgroup "IBB_IPLIMIT_STARTUP_CTL_1 (at 0x1dc49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_IPLIMIT_STEPPER                       = " "0 (DIS_IPLIMIT_STEPPER),1 (EN_IPLIMIT_STEPPER)"
    tree.end
    tree "IBB_IPLIMIT_STARTUP_CTL_2"
      sgroup "IBB_IPLIMIT_STARTUP_CTL_2 (at 0x1dc4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   STARTUP_IPLIMIT                          = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CURRENT_STEP_SIZE                        = " "0 (MA50),1 (MA100),2 (MA150),3 (MA200)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIMIT_STEPPER_CYCLES                   = " "0 (CYCLES_PER_STEP_8),1 (CYCLES_PER_STEP_16),2 (CYCLES_PER_STEP_32),3 (CYCLES_PER_STEP_64)"
    tree.end
    tree "IBB_CURRENT_LIMIT"
      sgroup "IBB_CURRENT_LIMIT (at 0x1dc4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CURRENT_LIMIT                         = " "0 (ILIM_DIS),1 (ILIM_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ILIMIT_COUNT                             = " "0 (CYC8),1 (CYC16),2 (CYC32),3 (CYC64)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   SET_CURRENT_MAX                          = "
    tree.end
    tree "IBB_CURRENT_SENSE"
      sgroup "IBB_CURRENT_SENSE (at 0x1dc4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SEL_C_COMP                               = " "0 (CURR_SNS_COMP_CAP_50FF),1 (CURR_SNS_COMP_CAP_70FF)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_GAIN                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "IBB_LOOP_COMP_CTL"
      sgroup "IBB_LOOP_COMP_CTL (at 0x1dc4d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LOOP_COMP_CAP                            = " "0 (COMP_CAP_96PF),1 (COMP_CAP_106PF),2 (COMP_CAP_116PF),3 (COMP_CAP_126PF)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOOP_COMP_RES                            = "
    tree.end
    tree "IBB_SLOPE_COMP_CURRENT"
      sgroup "IBB_SLOPE_COMP_CURRENT (at 0x1dc4e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLOPE_COMP_CURRENT                       = " "0 (COMP_CURR_0P25UA),1 (COMP_CURR_0P5UA),2 (COMP_CURR_0P75UA),3 (COMP_CURR_1UA),4 (COMP_CURR_1P25UA),5 (COMP_CURR_1P5UA),6 (COMP_CURR_1P75UA),7 (COMP_CURR_2UA)"
    tree.end
    tree "IBB_INZERO_CTL"
      sgroup "IBB_INZERO_CTL (at 0x1dc4f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc4f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc4f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   INZERO_DELAY                             = " "0 (NS70),1 (NS35_1),2 (NS35_2),3 (NS25)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OVERRIDE_VOLTAGE_OFFSET                  = " "0 (DEFAULT_VOLTAGE_OFFSET),1 (OVERRIDE_VOLTAGE_OFFSET)"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   VOLTAGE_OFFSET                           = " "0 (VOFF_0MV),1 (VOFF_M1MV),2 (VOFF_M4MV),3 (VOFF_M8MV),4 (VOFF_1MV),5 (VOFF_4MV),6 (VOFF_6MV),7 (VOFF_8MV)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZX_DETECT_ON                             = " "0 (INZERODET_ZERO),1 (INZERODET_EN)"
    tree.end
    tree "IBB_PS_CTL"
      sgroup "IBB_PS_CTL (at 0x1dc50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PS                                    = " "0 (DIS_PS),1 (EN_PS)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_THRESHOLD                             = " "0 (UA0),1 (UA0P5),2 (UA1),3 (UA1P5),4 (UA2),5 (UA2P5),6 (UA3),7 (UA3P5)"
    tree.end
    tree "IBB_PWM_CTL_1"
      sgroup "IBB_PWM_CTL_1 (at 0x1dc51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UNLIMITED_DUTY_CYCLE                     = " "0 (LIMITED_DUTY_CYCLE),1 (UNLIMITED_DUTY_CYCLE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   MAX_DUTY_CYCLE                           = " "0 (NS26),1 (NS52),2 (NS78),3 (NS104)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MIN_DUTY_CYCLE                           = " "0 (NS26),1 (NS52),2 (NS78),3 (NS104)"
    tree.end
    tree "IBB_PWM_CTL_2"
      sgroup "IBB_PWM_CTL_2 (at 0x1dc52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x5 1 "  [ 5: 2]   ERR_AMP_GAIN                             = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIMIT_BLANK_TIME                       = " "0 (NS60_1),1 (NS40),2 (NS60_2),3 (NS120)"
    tree.end
    tree "IBB_RDSON_MNGMNT"
      sgroup "IBB_RDSON_MNGMNT (at 0x1dc53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NFET_SLEW                                = " "0 (NFET_HALF_SLEW),1 (NFET_FULL_SLEW)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFET_SLEW                                = " "0 (PFET_HALF_SLEW),1 (PFET_FULL_SLEW)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVERRIDE_NFET_SW_SIZE                    = " "0 (DEFAULT_NFET_SW_SIZE),1 (OVERRIDE_NFET_SW_SIZE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   NFET_SW_SIZE                             = " "0 (LCD_NFET_HALF_SIZE),1 (LCD_NFET_FULL_SIZE),2 (AMOLED_NFET_HALF_SIZE),3 (AMOLED_NFET_FULL_SIZE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OVERRIDE_PFET_SW_SIZE                    = " "0 (DEFAULT_PFET_SW_SIZE),1 (OVERRIDE_PFET_SW_SIZE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFET_SW_SIZE                             = " "0 (LCD_PFET_HALF_SIZE),1 (LCD_PFET_FULL_SIZE),2 (AMOLED_PFET_HALF_SIZE),3 (AMOLED_PFET_FULL_SIZE)"
    tree.end
    tree "IBB_SHORT_CIRCUIT_CTL"
      sgroup "IBB_SHORT_CIRCUIT_CTL (at 0x1dc54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SHORT_CIRCUIT_DEB                        = " "0 (US2),1 (US4),2 (US16),3 (US32)"
    tree.end
    tree "IBB_VREG_OK_CTL"
      sgroup "IBB_VREG_OK_CTL (at 0x1dc55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_VREG_NOT_OK_BLANK                     = " "0 (DIS_VREG_NOT_OK_BLANKING),1 (EN_VREG_NOT_OK_BLANKING)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VREG_NOT_OK_BLANKTIME                    = " "0 (MS8),1 (MS16),2 (MS32),3 (MS64)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_OK_DEB                              = " "0 (US2),1 (US4),2 (US8),3 (US16)"
    tree.end
    tree "IBB_NONOVERLAP_TIME_1"
      sgroup "IBB_NONOVERLAP_TIME_1 (at 0x1dc56)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVERRIDE_NONOVERLAP                      = " "0 (DEFAULT_NONOVERLAP_TIME),1 (OVERRIDE_NONOVERLAP_TIME)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NONOVERLAP_PFET                          = " "0 (GATE_DELAY_8),1 (GATE_DELAY_6),2 (GATE_DELAY_4),3 (GATE_DELAY_2),4 (GATE_DELAY_22),5 (GATE_DELAY_18),6 (GATE_DELAY_14),7 (GATE_DELAY_10)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NONOVERLAP_NFET                          = " "0 (GATE_DELAY_8),1 (GATE_DELAY_6),2 (GATE_DELAY_4),3 (GATE_DELAY_2),4 (GATE_DELAY_22),5 (GATE_DELAY_18),6 (GATE_DELAY_14),7 (GATE_DELAY_10)"
    tree.end
    tree "IBB_NONOVERLAP_TIME_2"
      sgroup "IBB_NONOVERLAP_TIME_2 (at 0x1dc57)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   P2N_MUX_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N2P_MUX_SEL                              = " "0, 1"
    tree.end
    tree "IBB_PWRUP_PWRDN_CTL_1"
      sgroup "IBB_PWRUP_PWRDN_CTL_1 (at 0x1dc58)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWRUP_DLY1_SRC                           = " "0 (BIAS_ACTIVE),1 (LAB_VREG_OK)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_PWRUP_DLY1                            = " "0 (DIS_PWRUP_DLY1),1 (EN_PWRUP_DLY1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PWRUP_DLY1                               = " "0 (MS1),1 (MS2),2 (MS4),3 (MS8)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_PWRDN_DLY2                            = " "0 (DIS_PWRDN_DLY2),1 (EN_PWRDN_DLY2)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWRDN_DLY2_SRC                           = " "0 (IBB_DIS),1 (IBB_DISCHARGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWRDN_DLY2                               = " "0 (MS1),1 (MS2),2 (MS4),3 (MS8)"
    tree.end
    tree "IBB_PWRUP_PWRDN_CTL_2"
      sgroup "IBB_PWRUP_PWRDN_CTL_2 (at 0x1dc59)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WAIT_VPH_PWR_OK                          = " "0 (DIS_WAIT_VPH_PWR_OK),1 (EN_WAIT_VPH_PWR_OK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_MBG_OK                              = " "0 (DIS_MASK_MBG_OK),1 (EN_MASK_MBG_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IBB_DIS_DLY                              = " "0 (MS0),1 (MS1),2 (MS2),3 (MS4)"
    tree.end
    tree "IBB_SWIRE_CTL"
      sgroup "IBB_SWIRE_CTL (at 0x1dc5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OUTPUT_VOLTAGE_AT_ONE_PULSE              = "
    tree.end
    tree "IBB_OUTPUT_VOLTAGE_INTL"
      sgroup "IBB_OUTPUT_VOLTAGE_INTL (at 0x1dc5b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE_INTERNAL              = "
    tree.end
    tree "IBB_OUTPUT_SLEW_CTL"
      sgroup "IBB_OUTPUT_SLEW_CTL (at 0x1dc5c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DIGITAL_SLEW_CTL                      = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   STEP_INTERVAL_TIME                       = " "0 (MS0P25),1 (MS0P5),2 (MS1),3 (MS2),4 (MS4),5 (MS8),6 (MS16),7 (MS32)"
    tree.end
    tree "IBB_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD"
      sgroup "IBB_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD (at 0x1dc5d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   SET_OUTPUT_VOLTAGE_DIS_AFVC_THRESHOLD    = "
    tree.end
    tree "IBB_RAMP_OFFSET"
      sgroup "IBB_RAMP_OFFSET (at 0x1dc5e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_OFFSET                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "IBB_SOFT_START_CTL"
      sgroup "IBB_SOFT_START_CTL (at 0x1dc5f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc5f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc5f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SOFT_START                               = " "0, 1, 2, 3"
    tree.end
    tree "IBB_SPARE_CTL"
      sgroup "IBB_SPARE_CTL (at 0x1dc60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UNDEFINED_LV1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   POFF_CTL                                 = " "0 (SLOWER_PFET_OFF),1 (FASTER_PFET_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAST_STARTUP                             = " "0 (OLD_SOFT_START_FIXED_PS_THRESH),1 (FAST_CHARGING_START_DYNAMIC_PS_THRESH)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   ADJUST_CURRENT_LIMIT                     = " "0 (DEFAULT_CURRENT_LIMIT),1 (M20PCT_LOWER_CURRENT_LIMIT),2 (P40PCT_HIGHER_CURRENT_LIMIT),3 (P20PCT_HIGHER_CURRENT_LIMIT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_SHORT_CIRCUIT_PROTECTION             = " "0 (EN_SCP),1 (DIS_SCP)"
    tree.end
    tree "IBB_NLIMIT_DAC"
      sgroup "IBB_NLIMIT_DAC (at 0x1dc61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NLIMIT_DAC                               = " "0 (MA0),1 (MA80),2 (MA160),3 (MA240),4 (MA320),5 (MA400),6 (MA480),7 (MA560)"
    tree.end
    tree "IBB_PFM_CTL"
      sgroup "IBB_PFM_CTL (at 0x1dc62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_PFM                                   = " "0 (PWM_MODE),1 (PFM_MODE)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   PFM_HYSTERESIS                           = " "0 (HYS0MV_0),1 (HYS25MV),2 (HYS50MV),3 (HYS0MV_3)"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   PFM_PEAK_CURRENT                         = " "0 (MA150),1 (MA200),2 (MA250),3 (MA300),4 (MA350),5 (MA400),6 (MA450),7 (MA500)"
    tree.end
    tree "IBB_SPARE_CTL_2"
      sgroup "IBB_SPARE_CTL_2 (at 0x1dc63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   SPARES2                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARES2_2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARES2_1                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARES2_0                                = " "0, 1"
    tree.end
    tree "IBB_SWIRE_WLED_CTL1"
      sgroup "IBB_SWIRE_WLED_CTL1 (at 0x1dc64)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   AVDD_MIN                                 = "
    tree.end
    tree "IBB_SWIRE_WLED_CTL2"
      sgroup "IBB_SWIRE_WLED_CTL2 (at 0x1dc65)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x1--0x6 1 "  [ 6: 1]   AVDD_START                               = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AVDD_LSB                                 = " "0 (AVDD_LSB_300MV),1 (AVDD_LSB_150MV)"
    tree.end
    tree "IBB_ENABLE_CTL2"
      sgroup "IBB_ENABLE_CTL2 (at 0x1dc66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_GLITCH_REJ_LCD                        = " "0 (DIS_GLITCH_REJ_LCD),1 (EN_GLITCH_REJ_LCD)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_SAFE_DIS_PWRSTG                       = " "0 (DIS_SAFE_DISBLE_OF_POWER_STAGE),1 (EN_SAFE_DISBLE_OF_POWER_STAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_VPH_PWR_OK_ILIM                       = " "0 (DIS_VPH_PWR_OK_ILIM_CTL),1 (EN_VPH_PWR_OK_ILIM_CTL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CURRENT_CLAMP                            = "
    tree.end
    tree "IBB_ENABLE_CTL3"
      sgroup "IBB_ENABLE_CTL3 (at 0x1dc67)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dc670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdc670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   VPH_PWR_OK_DEB                           = " "0 (US0P5),1 (US1),2 (US2),3 (US4)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SWIRE_GLITCH_REJ_TIME_LCD                = " "0 (LCD_SWIRE_DEGLITCH_5US),1 (LCD_SWIRE_DEGLITCH_10US)"
    tree.end
    tree "IBB_SEC_ACCESS"
      sgroup "IBB_SEC_ACCESS (at 0x1dcd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "IBB_PERPH_RESET_CTL1"
      sgroup "IBB_PERPH_RESET_CTL1 (at 0x1dcd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "IBB_PERPH_RESET_CTL2"
      sgroup "IBB_PERPH_RESET_CTL2 (at 0x1dcd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "IBB_PERPH_RESET_CTL3"
      sgroup "IBB_PERPH_RESET_CTL3 (at 0x1dcda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "IBB_PERPH_RESET_CTL4"
      sgroup "IBB_PERPH_RESET_CTL4 (at 0x1dcdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "IBB_INT_TEST1"
      sgroup "IBB_INT_TEST1 (at 0x1dce0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "IBB_INT_TEST_VAL"
      sgroup "IBB_INT_TEST_VAL (at 0x1dce1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_SHUTDOWN_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SC_ERROR_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ILIMIT_ERROR_TEST_VAL                    = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_NOT_OK_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "IBB_DTEST1_ACCESS"
      sgroup "IBB_DTEST1_ACCESS (at 0x1dce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DTEST1_ACCESS                            = "
    tree.end
    tree "IBB_DTEST2_ACCESS"
      sgroup "IBB_DTEST2_ACCESS (at 0x1dce3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DTEST2_ACCESS                            = "
    tree.end
    tree "IBB_DTEST3_ACCESS"
      sgroup "IBB_DTEST3_ACCESS (at 0x1dce4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DTEST3_ACCESS                            = "
    tree.end
    tree "IBB_DTEST4_ACCESS"
      sgroup "IBB_DTEST4_ACCESS (at 0x1dce5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DTEST4_ACCESS                            = "
    tree.end
    tree "IBB_ATEST1_ACCESS"
      sgroup "IBB_ATEST1_ACCESS (at 0x1dce6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST1_ACCESS                            = " "0 (NO_SIGNAL),1 (ATEST_GM_2UA),2 (ATEST_BIAS1UA),3 (DISCHARGE_RAMP_ATEST),4 (PREAMP_TRIM_OUT),5 (RESERVED),6 (PWM_COMP),7 (BKSP1)"
    tree.end
    tree "IBB_ATEST2_ACCESS"
      sgroup "IBB_ATEST2_ACCESS (at 0x1dce7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2_ACCESS                            = " "0 (NO_SIGNAL),1 (RESERVED),2 (VREF_BUFFF_TRIM2_OUT),3 (VREF),4 (ERROR_AMP_OUT_TRIM),5 (PWR_DRV_ATEST),6 (IPLIMIT),7 (KSP2)"
    tree.end
    tree "IBB_ATEST3_ACCESS"
      sgroup "IBB_ATEST3_ACCESS (at 0x1dce8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST3_ACCESS                            = " "0 (NO_SIGNAL),1 (REF_CAP_CHARGED),2 (TOP_RES_1),3 (DIVIDER_TOP),4 (IBB_VREF),5 (INM_PREAMP),6 (BOT_RES_1),7 (DAC_OUT)"
    tree.end
    tree "IBB_ATEST4_ACCESS"
      sgroup "IBB_ATEST4_ACCESS (at 0x1dce9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dce90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdce90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST4_ACCESS                            = " "0 (NO_SIGNAL),1 (RESERVED),2 (PSKIP_THRESHOLD),3 (VFLOAT),4 (VBG_BY_R_CURRENT),5 (RING_KILL_MV),6 (PULSE_SKIP),7 (N_OFF_LV)"
    tree.end
    tree "IBB_TEST_CTL_1"
      sgroup "IBB_TEST_CTL_1 (at 0x1dcea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_PFM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_OFF_WIRTE_ONCE                     = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_OUTPUT_VOLTAGE_TEST                   = " "0 (DIS),1 (EN)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OUTPUT_VOLTAGE_TEST_MODE                 = " "0 (VM6P1),1 (VM6P2),2 (VM6P3),3 (VM6P4)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RDSON_TEST                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PFET_CTL                                 = " "0 (OFF),1 (ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NFET_CTL                                 = " "0 (OFF),1 (ON)"
    tree.end
    tree "IBB_TEST_CTL_2"
      sgroup "IBB_TEST_CTL_2 (at 0x1dceb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dceb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdceb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODULE_FORCE_ON                          = " "0 (NOT_FORCE_ON),1 (FORCE_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_PWR_STAGE_OFF                      = " "0 (NOT_FORCE_OFF),1 (FORCE_OFF)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ERRAMP_TRIM_DIS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ERRAMP_TRIM_CALIB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_TRIM_INZERO_OFFSET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DISABLE_PREAMP_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CALIB_BUFF_TRIM                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALIB_PREAMP_TRIM                        = " "0, 1"
    tree.end
    tree "IBB_DEBOUNCER_OVERRIDE"
      sgroup "IBB_DEBOUNCER_OVERRIDE (at 0x1dcec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DEB_VPH_PWR_OK                           = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DEB_ILIMIT                               = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEB_VREG_OK                              = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DEB_SC                                   = " "0 (NO_OVERRIDE),1 (BYPASS_DEBOUNCER),2 (OVERRIDE_TO_0),3 (OVERRIDE_TO_1)"
    tree.end
    tree "IBB_TEST_CTL_3"
      sgroup "IBB_TEST_CTL_3 (at 0x1dced)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dced0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdced0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   STATUS3_CTRL_SEL                         = "
    tree.end
    tree "IBB_TRIM_NUM"
      sgroup "IBB_TRIM_NUM (at 0x1dcf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        set &access:&cmd_addr %l 0x80dcf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xdc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdcf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
