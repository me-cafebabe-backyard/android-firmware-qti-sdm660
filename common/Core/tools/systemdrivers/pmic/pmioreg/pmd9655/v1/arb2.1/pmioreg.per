entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BUA_4UICC_DUAL_BATT_ALARM"
  tree "BUA_4UICC_DUAL_BATT_ALARM"
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_REVISION1 (at 0x1c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_REVISION2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_REVISION2 (at 0x1c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_TYPE"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_TYPE (at 0x1c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_SUBTYPE"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_SUBTYPE (at 0x1c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_STATUS1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_STATUS1 (at 0x1c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BATT_GONE_DETECTED                       = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_STATUS2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_STATUS2 (at 0x1c09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC4_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC3_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC2_ALARM_DETECTED                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UICC1_ALARM_DETECTED                     = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_RT_STS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_RT_STS (at 0x1c10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_STS                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_SET_TYPE"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_SET_TYPE (at 0x1c11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TYPE                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_HIGH"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_HIGH (at 0x1c12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_HIGH                          = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_LOW"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_POLARITY_LOW (at 0x1c13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LOW                           = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_CLR"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_CLR (at 0x1c14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_SET"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_SET (at 0x1c15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_SET                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_CLR"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_EN_CLR (at 0x1c16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_EN_CLR                        = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_STS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_LATCHED_STS (at 0x1c18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_PENDING_STS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_PENDING_STS (at 0x1c19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARMPENDING_STS                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_MID_SEL"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_MID_SEL (at 0x1c1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_PRIORITY"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_PRIORITY (at 0x1c1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_BUA_CTL1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_BUA_CTL1 (at 0x1c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_GONE_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   BATT_RMV_DEB                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LDO_SHUTDOWN_DELAY                       = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL1 (at 0x1c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUA_EN                                   = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_EN_CTL2 (at 0x1c47)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BAT_GONE_COMP                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_SEC_ACCESS"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_SEC_ACCESS (at 0x1cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL1 (at 0x1cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL2"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL2 (at 0x1cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL3"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL3 (at 0x1cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL4"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_PERPH_RESET_CTL4 (at 0x1cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST1 (at 0x1ce0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST_VAL"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_INT_TEST_VAL (at 0x1ce1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UICC4_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UICC3_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UICC2_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UICC1_ALARM_TEST_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BATT_ALARM_TEST_VAL                      = " "0, 1"
    tree.end
    tree "BUA_4UICC_DUAL_BATT_ALARM_TEST1"
      sgroup "BUA_4UICC_DUAL_BATT_ALARM_TEST1 (at 0x1ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST_SEL2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "BUCK_CMN_MOD"
  tree "BUCK_CMN_MOD"
    tree "BUCK_CMN_MOD_REVISION1"
      sgroup "BUCK_CMN_MOD_REVISION1 (at 0x11000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUCK_CMN_MOD_REVISION2"
      sgroup "BUCK_CMN_MOD_REVISION2 (at 0x11001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUCK_CMN_MOD_REVISION3"
      sgroup "BUCK_CMN_MOD_REVISION3 (at 0x11002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BUCK_CMN_MOD_REVISION4"
      sgroup "BUCK_CMN_MOD_REVISION4 (at 0x11003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BUCK_CMN_MOD_PERPH_TYPE"
      sgroup "BUCK_CMN_MOD_PERPH_TYPE (at 0x11004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUCK_CMN_MOD_PERPH_SUBTYPE"
      sgroup "BUCK_CMN_MOD_PERPH_SUBTYPE (at 0x11005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUCK_CMN_MOD_STATUS_BUF_TRIM"
      sgroup "BUCK_CMN_MOD_STATUS_BUF_TRIM (at 0x1100a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BUFFER_TRIM_OUT                          = " "0, 1"
    tree.end
    tree "BUCK_CMN_MOD_BUCK_CMN_ENABLE"
      sgroup "BUCK_CMN_MOD_BUCK_CMN_ENABLE (at 0x11046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BUCK_CMN                              = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0 (FOLLOW_CLK_REQ_DISABLED),1 (FOLLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BUCK_CMN_MOD_QM_MODE"
      sgroup "BUCK_CMN_MOD_QM_MODE (at 0x11051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QM_EN                                    = " "0 (QUIET_MODE_DISABLED),1 (QUIET_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_QM_EXT_EN                         = " "0 (IGNORE_QM_EXT),1 (FOLLOW_QM_EXT)"
    tree.end
    tree "BUCK_CMN_MOD_ECM_VREF_PROG"
      sgroup "BUCK_CMN_MOD_ECM_VREF_PROG (at 0x11052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ECM_VREF_PROG                            = " "0, 1, 2, 3"
    tree.end
    tree "BUCK_CMN_MOD_VREF_PRECH_PROG"
      sgroup "BUCK_CMN_MOD_VREF_PRECH_PROG (at 0x11053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREF_PRECH_PROG                          = " "0, 1, 2, 3"
    tree.end
    tree "BUCK_CMN_MOD_SEC_ACCESS"
      sgroup "BUCK_CMN_MOD_SEC_ACCESS (at 0x110d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUCK_CMN_MOD_PERPH_RESET_CTL2"
      sgroup "BUCK_CMN_MOD_PERPH_RESET_CTL2 (at 0x110d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUCK_CMN_MOD_PERPH_RESET_CTL3"
      sgroup "BUCK_CMN_MOD_PERPH_RESET_CTL3 (at 0x110da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUCK_CMN_MOD_PERPH_RESET_CTL4"
      sgroup "BUCK_CMN_MOD_PERPH_RESET_CTL4 (at 0x110db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUCK_CMN_MOD_TEST1"
      sgroup "BUCK_CMN_MOD_TEST1 (at 0x110e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST1_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BUCK_CMN_MOD_TEST2"
      sgroup "BUCK_CMN_MOD_TEST2 (at 0x110e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   DTEST3_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST4_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BUCK_CMN_MOD_TEST3"
      sgroup "BUCK_CMN_MOD_TEST3 (at 0x110e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ATEST4_SEL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ATEST3_SEL                               = " "0, 1, 2, 3"
    tree.end
    tree "BUCK_CMN_MOD_TEST4"
      sgroup "BUCK_CMN_MOD_TEST4 (at 0x110e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0 (USE_MAIN_CLK),1 (USE_ALT_CLK)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0 (ALT_CLK_DTEST1),1 (ALT_CLK_DTEST2),2 (ALT_CLK_DTEST3),3 (ALT_CLK_DTEST4)"
    tree.end
    tree "BUCK_CMN_MOD_TEST5_ECM_VREF"
      sgroup "BUCK_CMN_MOD_TEST5_ECM_VREF (at 0x110e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (BUFFER_MODE),1 (OFFSET_TRIM_MODE)"
    tree.end
    tree "BUCK_CMN_MOD_TEST6_REFDAC_VREF"
      sgroup "BUCK_CMN_MOD_TEST6_REFDAC_VREF (at 0x110e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (BUFFER_MODE),1 (OFFSET_TRIM_MODE)"
    tree.end
    tree "BUCK_CMN_MOD_TRIM_NUM"
      sgroup "BUCK_CMN_MOD_TRIM_NUM (at 0x110f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "BUCK_CMN_MOD_REFDAC_VREF_TRIM"
      sgroup "BUCK_CMN_MOD_REFDAC_VREF_TRIM (at 0x110f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   REFDAC_VREF_TRIM                         = "
    tree.end
    tree "BUCK_CMN_MOD_ECM_VREF_TRIM"
      sgroup "BUCK_CMN_MOD_ECM_VREF_TRIM (at 0x110f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ECM_VREF_TRIM                            = "
    tree.end
  tree.end
tree.end
tree "BUCK_ECM_FREQ"
  tree "BUCK_ECM_FREQ"
    tree "BUCK_ECM_FREQ_REVISION1"
      sgroup "BUCK_ECM_FREQ_REVISION1 (at 0x3b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUCK_ECM_FREQ_REVISION2"
      sgroup "BUCK_ECM_FREQ_REVISION2 (at 0x3b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUCK_ECM_FREQ_PERPH_TYPE"
      sgroup "BUCK_ECM_FREQ_PERPH_TYPE (at 0x3b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUCK_ECM_FREQ_PERPH_SUBTYPE"
      sgroup "BUCK_ECM_FREQ_PERPH_SUBTYPE (at 0x3b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUCK_ECM_FREQ_CLK_ENABLE"
      sgroup "BUCK_ECM_FREQ_CLK_ENABLE (at 0x3b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "BUCK_ECM_FREQ_CLK_DIV"
      sgroup "BUCK_ECM_FREQ_CLK_DIV (at 0x3b50)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803b500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "BUCK_ECM_FREQ_CLK_PHASE"
      sgroup "BUCK_ECM_FREQ_CLK_PHASE (at 0x3b51)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803b510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "BUCK_ECM_FREQ_GANG_CTL1"
      sgroup "BUCK_ECM_FREQ_GANG_CTL1 (at 0x3bc0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803bc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3bc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "BUCK_ECM_FREQ_GANG_CTL2"
      sgroup "BUCK_ECM_FREQ_GANG_CTL2 (at 0x3bc1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803bc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3bc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "BUCK_ECM_FREQ_SEC_ACCESS"
      sgroup "BUCK_ECM_FREQ_SEC_ACCESS (at 0x3bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUCK_ECM_FREQ_PERPH_RESET_CTL2"
      sgroup "BUCK_ECM_FREQ_PERPH_RESET_CTL2 (at 0x3bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUCK_ECM_FREQ_PERPH_RESET_CTL3"
      sgroup "BUCK_ECM_FREQ_PERPH_RESET_CTL3 (at 0x3bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUCK_ECM_FREQ_PERPH_RESET_CTL4"
      sgroup "BUCK_ECM_FREQ_PERPH_RESET_CTL4 (at 0x3bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUCK_ECM_FREQ_TEST1"
      sgroup "BUCK_ECM_FREQ_TEST1 (at 0x3be2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        set &access:&cmd_addr %l 0x803be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LOGGER_OK                                = " "0 (LOGGER_INACTIVE),1 (LOGGER_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LOGGER_FULL                              = " "0 (LOGGER_NOT_FULL),1 (LOGGER_IS_FULL)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HALF_ENTRY                               = " "0 (FULL_ENTRIES),1 (LAST_HALF_ENTRY)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_FIFO_SIZE"
      sgroup "BUS_FIFO_SIZE (at 0x40b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80040b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FIFO_SIZE                                = " "0 (FIFO64X64),1 (FIFO128X64),2 (FIFO256X64),3 (reserved)"
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_LOGGER_EN"
      sgroup "BUS_LOGGER_EN (at 0x446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LOGGER_EN                                = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "BUS_LOGGER_CTL"
      sgroup "BUS_LOGGER_CTL (at 0x450)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PERPH_FILTER                             = " "0 (PERPH_FILTER_OFF),1 (PERPH_FILTER_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IGNORE_TIMESTAMP                         = " "0 (LOG_TIMESTAMP),1 (IGNORE_TIMESTAMP)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   IGNORE_READS                             = " "0 (LOG_READS_AND_WRITES),1 (LOG_WRITES_ONLY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WRAP                                     = " "0 (NO_WRAP),1 (WRAP)"
    tree.end
    tree "BUS_LOGGER_PID"
      sgroup "BUS_LOGGER_PID (at 0x452)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOGGER_PID                               = "
    tree.end
    tree "BUS_LOGGER_SID"
      sgroup "BUS_LOGGER_SID (at 0x453)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOGGER_SID                               = " "0, 1, 2, 3"
    tree.end
    tree "BUS_MEM_INTF_ADDR"
      sgroup "BUS_MEM_INTF_ADDR (at 0x454)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR                            = "
    tree.end
    tree "BUS_CAPTURE_INC"
      sgroup "BUS_CAPTURE_INC (at 0x456)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAPTURE_INC                              = " "0 (reserved),1 (CAPTURE_AND_INC)"
    tree.end
    tree "BUS_MEM_INTF_DATA0"
      sgroup "BUS_MEM_INTF_DATA0 (at 0x458)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA0                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA1"
      sgroup "BUS_MEM_INTF_DATA1 (at 0x459)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA1                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA2"
      sgroup "BUS_MEM_INTF_DATA2 (at 0x45a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA2                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA3"
      sgroup "BUS_MEM_INTF_DATA3 (at 0x45b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA3                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA4"
      sgroup "BUS_MEM_INTF_DATA4 (at 0x45c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA4                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA5"
      sgroup "BUS_MEM_INTF_DATA5 (at 0x45d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA5                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA6"
      sgroup "BUS_MEM_INTF_DATA6 (at 0x45e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA6                           = "
    tree.end
    tree "BUS_MEM_INTF_DATA7"
      sgroup "BUS_MEM_INTF_DATA7 (at 0x45f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x80045f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_DATA7                           = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL1"
      sgroup "BUS_PERPH_RESET_CTL1 (at 0x4d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HFRC_OK                                  = " "0 (HFRC_OFF),1 (HFRC_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   IDSS_TIMER_EXPIRED                       = " "0 (IDSS_TIMER_NOT_EXPIRED),1 (IDSS_TIMER_EXPIRED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HF_GP_SEL_STATUS                         = " "0 (SEL_HFRC),1 (SEL_XO)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HF_SMPS_SEL_STATUS                       = " "0 (SEL_HFRC),1 (SEL_XO)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SLP_CLK_PAD_VREG_OK                      = " "0 (SLP_CLK_PAD_VREG_NOT_OK),1 (SLP_CLK_PAD_VREG_OK)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SLP_CLK_SOURCE                           = " "0 (RESERVED_0),1 (EXT_32K),2 (CALRC1),3 (LFRC_DIV2),4 (RESERVED_4),5 (XO_DIV),6 (RESERVED_6),7 (AON_32K)"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_RT_STS                   = " "0 (CLK32K_NOT_HALT),1 (CLK32K_HALT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_RT_STS                       = " "0 (XO_NOT_HALT),1 (XO_HALT)"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_TYPE                     = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_HIGH                     = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LOW                      = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_EN_SET                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_EN_CLR                   = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_LATCHED_STS              = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_PENDING_STS              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0 (SMPS_CLK_BASE_ON_WARM_SLEEP_B_AND_HF_HALT_B),1 (SMPS_CLK_HFRC),2 (SMPS_CLK_XO),3 (SMPS_CLK_BASE_ON_HALT_B)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_SEL                                = " "0 (GP_CLK_BASE_ON_WARM_SLEEP_B_AND_HF_HALT_B),1 (GP_CLK_HFRC),2 (GP_CLK_XO),3 (GP_CLK_BASE_ON_HALT_B)"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_ALT_SC                                = " "0 (ALT_SC_DIVIDER_DIS),1 (ALT_SC_DIVIDER_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0 (ALT_SC_OFF),1 (ALT_SC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0 (ALT_RTC_OFF),1 (ALT_RTC_ON)"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EXT32K_DIV_SEL                           = " "0 (DIV32768),1 (DIV32764)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EXT32K_CLK_SEL                           = " "0 (CALRC),1 (EXT32K)"
    tree.end
    tree "CLK_DIST_CLK_CTL5"
      sgroup "CLK_DIST_CLK_CTL5 (at 0x5944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_32K_SEL                              = " "0 (FOLLOW_32K_HALT),1 (LFRC_AON),2 (CLK_32K_SOURCE),3 (reserved)"
    tree.end
    tree "CLK_DIST_XO_HALT_CTL"
      sgroup "CLK_DIST_XO_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_HW_XO_HALT                        = " "0 (NOT_FOLLOW_HW_XO_HALT),1 (FOLLOW_HW_XO_HALT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO_HALT                            = " "0 (XO_HALT_NOT_FORCED),1 (XO_HALT_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO_HALT                             = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_HFRC_CTL"
      sgroup "CLK_DIST_HFRC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_HFRC_OSC_ON                        = " "0 (HFRC_NOT_FORCED),1 (HFRC_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HFRC_OSC_HW_CTL                          = " "0 (HFRC_NOT_FOLLOW_HW_DEMAND),1 (HFRC_FOLLOW_HW_DEMAND)"
    tree.end
    tree "CLK_DIST_CLK32K_HALT_CTL"
      sgroup "CLK_DIST_CLK32K_HALT_CTL (at 0x5947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_HW_CLK32K_HALT                    = " "0 (NOT_FOLLOW_HW_CLK32K_HALT),1 (FOLLOW_HW_CLK32K_HALT)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_CLK32K_HALT                        = " "0 (CLK32K_HALT_NOT_FORCED),1 (CLK32K_HALT_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_CLK32K_HALT                         = " "0 (DONT_HOLD_HALT_COND),1 (HOLD_HALT_COND)"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (HIZ_INPUT),1 (PULLDOWN_INPUT)"
    tree.end
    tree "CLK_DIST_CLK98K_CTL"
      sgroup "CLK_DIST_CLK98K_CTL (at 0x5949)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_CLK98K                             = " "0 (CLK98K_NOT_FORCED),1 (CLK98K_FORCED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_CLK98K                         = " "0 (NOT_FOLLOW_HW_CLK98K_ENA),1 (FOLLOW_HW_CLK98K_ENA)"
    tree.end
    tree "CLK_DIST_PMIC_SLEEP_CTL"
      sgroup "CLK_DIST_PMIC_SLEEP_CTL (at 0x594a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80594a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x594a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_AWAKE_EN                           = " "0 (NOT_FORCE_AWAKE),1 (FORCE_PMIC_AWAKE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HW_EN                             = " "0 (PMIC_AWAKE_NOT_FOLLOW_HW),1 (PMIC_AWAKE_FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_SPARE1"
      sgroup "CLK_DIST_SPARE1 (at 0x5951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE2"
      sgroup "CLK_DIST_SPARE2 (at 0x5952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SPARE3"
      sgroup "CLK_DIST_SPARE3 (at 0x5953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK32K_HALT_DET_TEST_VAL                 = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_HALT_DET_TEST_VAL                     = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0 (HIZ),1 (HF_CLK),2 (DTEST1),3 (DIV_CLK1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0 (NORMAL),1 (TEST_CLK_ON_32K)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0 (NORMAL),1 (TEST_CLK_ON_1K)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0 (NORMAL),1 (DTEST1_ON_SMPL)"
    tree.end
    tree "CLK_DIST_TEST3"
      sgroup "CLK_DIST_TEST3 (at 0x59e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   XO_BCKBLNK_SEL1                          = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_BCKBLNK_SEL0                          = "
    tree.end
    tree "CLK_DIST_TEST4"
      sgroup "CLK_DIST_TEST4 (at 0x59e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HFRC_TEST_EN                             = " "0 (HFRC_TEST_DISENA),1 (HFRC_TEST_ENA)"
    tree.end
    tree "CLK_DIST_TEST5"
      sgroup "CLK_DIST_TEST5 (at 0x59e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   XO_BCKBLNK_CLK_EN1                       = " "0 (XO_BCKBLNK_DISENA),1 (XO_BCKBLNK_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_BCKBLNK_CLK_EN0                       = " "0 (XO_BCKBLNK_DISENA),1 (XO_BCKBLNK_ENA)"
    tree.end
    tree "CLK_DIST_TEST6"
      sgroup "CLK_DIST_TEST6 (at 0x59e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST_SEL                                = " "0 (HIZ),1 (BCKBLNK_CLK0),2 (BCKBLNK_CLK1),3 (ZERO_3)"
    tree.end
    tree "CLK_DIST_TEST7"
      sgroup "CLK_DIST_TEST7 (at 0x59e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_GP_ENA                             = " "0 (NOT_FORCE),1 (FORCE_ENA)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_GP_ENA                            = " "0 (NOT_FOLLOW_HW),1 (FOLLOW_HW)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_SMPS_ENA                           = " "0 (NOT_FORCE),1 (FORCE_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SMPS_ENA                          = " "0 (NOT_FOLLOW_HW),1 (FOLLOW_HW)"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_HFRC_TRIM"
      sgroup "CLK_DIST_HFRC_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   HFRC_TRIM                                = "
    tree.end
    tree "CLK_DIST_LFRC_AON_TRIM"
      sgroup "CLK_DIST_LFRC_AON_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   LFRC_AON_TRIM                            = "
    tree.end
  tree.end
tree.end
tree "DIV_CLK1"
  tree "DIV_CLK1"
    tree "DIV_CLK1_REVISION1"
      sgroup "DIV_CLK1_REVISION1 (at 0x5b00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "DIV_CLK1_REVISION2"
      sgroup "DIV_CLK1_REVISION2 (at 0x5b01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "DIV_CLK1_PERPH_TYPE"
      sgroup "DIV_CLK1_PERPH_TYPE (at 0x5b04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "DIV_CLK1_PERPH_SUBTYPE"
      sgroup "DIV_CLK1_PERPH_SUBTYPE (at 0x5b05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "DIV_CLK1_STATUS1"
      sgroup "DIV_CLK1_STATUS1 (at 0x5b08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_OK                                = " "0 (DIVIDER_OFF),1 (DIVIDER_ON)"
    tree.end
    tree "DIV_CLK1_DIV_CTL1"
      sgroup "DIV_CLK1_DIV_CTL1 (at 0x5b43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DIV_FACTOR                               = " "0 (XO_DIV1_0),1 (XO_DIV1),2 (XO_DIV2),3 (XO_DIV4),4 (XO_DIV8),5 (XO_DIV16),6 (XO_DIV32),7 (XO_DIV64)"
    tree.end
    tree "DIV_CLK1_EN_CTL"
      sgroup "DIV_CLK1_EN_CTL (at 0x5b46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIVCLK_EN                                = " "0 (DIVCLK_DIS),1 (DIVCLK_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "DIV_CLK1_SEC_ACCESS"
      sgroup "DIV_CLK1_SEC_ACCESS (at 0x5bd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL1"
      sgroup "DIV_CLK1_PERPH_RESET_CTL1 (at 0x5bd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL2"
      sgroup "DIV_CLK1_PERPH_RESET_CTL2 (at 0x5bd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL3"
      sgroup "DIV_CLK1_PERPH_RESET_CTL3 (at 0x5bda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "DIV_CLK1_PERPH_RESET_CTL4"
      sgroup "DIV_CLK1_PERPH_RESET_CTL4 (at 0x5bdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        set &access:&cmd_addr %l 0x805bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
  tree.end
tree.end
tree "ECM_MSTR"
  tree "ECM_MSTR"
    tree "ECM_MSTR_REVISION1"
      sgroup "ECM_MSTR_REVISION1 (at 0x3a00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "ECM_MSTR_REVISION2"
      sgroup "ECM_MSTR_REVISION2 (at 0x3a01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "ECM_MSTR_PERPH_TYPE"
      sgroup "ECM_MSTR_PERPH_TYPE (at 0x3a04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "ECM_MSTR_PERPH_SUBTYPE"
      sgroup "ECM_MSTR_PERPH_SUBTYPE (at 0x3a05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "ECM_MSTR_STATUS1"
      sgroup "ECM_MSTR_STATUS1 (at 0x3a08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL_OK                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "ECM_MSTR_EN_CTL"
      sgroup "ECM_MSTR_EN_CTL (at 0x3a46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GLOBAL_ENABLE                            = " "0 (DISABLE),1 (ENABLE)"
    tree.end
    tree "ECM_MSTR_CAL_CTRL"
      sgroup "ECM_MSTR_CAL_CTRL (at 0x3a50)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CALIBRATION_ENABLE                       = " "0 (CALIBRATION_DISABLE),1 (CALIBRATION_ENABLE)"
      textline ""
      hexmask.long.byte 0x0 0x2--0x6 1 "  [ 6: 2]   CALIBRATION_COUNT                        = "
    tree.end
    tree "ECM_MSTR_SAMP_A"
      sgroup "ECM_MSTR_SAMP_A (at 0x3a54)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMP_A                                   = "
    tree.end
    tree "ECM_MSTR_SAMP_B"
      sgroup "ECM_MSTR_SAMP_B (at 0x3a55)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SAMP_B                                   = "
    tree.end
    tree "ECM_MSTR_SAMP_CTRL0"
      sgroup "ECM_MSTR_SAMP_CTRL0 (at 0x3a56)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SAMP_SEL                                 = " "0 (SAMP_A),1 (SAMP_B)"
    tree.end
    tree "ECM_MSTR_CHOP_CTRL"
      sgroup "ECM_MSTR_CHOP_CTRL (at 0x3a57)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHOP_SEL                                 = " "0 (CHOP_HALF),1 (CHOP_05MS)"
    tree.end
    tree "ECM_MSTR_COUNT_CTL"
      sgroup "ECM_MSTR_COUNT_CTL (at 0x3a60)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COUNTER_ENABLE                           = " "0 (COUNTER_DISABLE),1 (COUNTER_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   COUNTER_CLEAR                            = " "0 (COUNTER_CLEAR_FALSE),1 (COUNTER_CLEAR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   COUNTER_MODE                             = " "0 (COUNTER_INCR_RISING_EDGE),1 (COUNTER_INCR_LEVEL)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   COUNTER_SRC                              = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4)"
    tree.end
    tree "ECM_MSTR_COUNT_0"
      sgroup "ECM_MSTR_COUNT_0 (at 0x3a61)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COUNTER_0                                = "
    tree.end
    tree "ECM_MSTR_COUNT_1"
      sgroup "ECM_MSTR_COUNT_1 (at 0x3a62)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803a620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   COUNTER_1                                = "
    tree.end
    tree "ECM_MSTR_SEC_ACCESS"
      sgroup "ECM_MSTR_SEC_ACCESS (at 0x3ad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "ECM_MSTR_PERPH_RESET_CTL1"
      sgroup "ECM_MSTR_PERPH_RESET_CTL1 (at 0x3ad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "ECM_MSTR_PERPH_RESET_CTL2"
      sgroup "ECM_MSTR_PERPH_RESET_CTL2 (at 0x3ad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "ECM_MSTR_PERPH_RESET_CTL3"
      sgroup "ECM_MSTR_PERPH_RESET_CTL3 (at 0x3ada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "ECM_MSTR_PERPH_RESET_CTL4"
      sgroup "ECM_MSTR_PERPH_RESET_CTL4 (at 0x3adb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "ECM_MSTR_DTEST_SEL"
      sgroup "ECM_MSTR_DTEST_SEL (at 0x3ae2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        set &access:&cmd_addr %l 0x803ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "GPIO01"
  tree "GPIO01"
    tree "GPIO01_REVISION1"
      sgroup "GPIO01_REVISION1 (at 0xc000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO01_REVISION2"
      sgroup "GPIO01_REVISION2 (at 0xc001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO01_REVISION3"
      sgroup "GPIO01_REVISION3 (at 0xc002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO01_REVISION4"
      sgroup "GPIO01_REVISION4 (at 0xc003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO01_PERPH_TYPE"
      sgroup "GPIO01_PERPH_TYPE (at 0xc004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO01_PERPH_SUBTYPE"
      sgroup "GPIO01_PERPH_SUBTYPE (at 0xc005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO01_STATUS1"
      sgroup "GPIO01_STATUS1 (at 0xc008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO01_INT_RT_STS"
      sgroup "GPIO01_INT_RT_STS (at 0xc010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO01_INT_SET_TYPE"
      sgroup "GPIO01_INT_SET_TYPE (at 0xc011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO01_INT_POLARITY_HIGH"
      sgroup "GPIO01_INT_POLARITY_HIGH (at 0xc012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO01_INT_POLARITY_LOW"
      sgroup "GPIO01_INT_POLARITY_LOW (at 0xc013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO01_INT_LATCHED_CLR"
      sgroup "GPIO01_INT_LATCHED_CLR (at 0xc014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO01_INT_EN_SET"
      sgroup "GPIO01_INT_EN_SET (at 0xc015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO01_INT_EN_CLR"
      sgroup "GPIO01_INT_EN_CLR (at 0xc016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO01_INT_LATCHED_STS"
      sgroup "GPIO01_INT_LATCHED_STS (at 0xc018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO01_INT_PENDING_STS"
      sgroup "GPIO01_INT_PENDING_STS (at 0xc019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO01_INT_MID_SEL"
      sgroup "GPIO01_INT_MID_SEL (at 0xc01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO01_INT_PRIORITY"
      sgroup "GPIO01_INT_PRIORITY (at 0xc01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO01_MODE_CTL"
      sgroup "GPIO01_MODE_CTL (at 0xc040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO01_DIG_VIN_CTL"
      sgroup "GPIO01_DIG_VIN_CTL (at 0xc041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO01_DIG_PULL_CTL"
      sgroup "GPIO01_DIG_PULL_CTL (at 0xc042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO01_DIG_IN_DTEST_SEL"
      sgroup "GPIO01_DIG_IN_DTEST_SEL (at 0xc043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO01_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO01_DIG_OUT_SOURCE_CTL (at 0xc044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO01_DIG_OUT_DRV_CTL"
      sgroup "GPIO01_DIG_OUT_DRV_CTL (at 0xc045)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO01_EN_CTL"
      sgroup "GPIO01_EN_CTL (at 0xc046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO01_ANA_PASS_THRU_SEL"
      sgroup "GPIO01_ANA_PASS_THRU_SEL (at 0xc04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO01_SEC_ACCESS"
      sgroup "GPIO01_SEC_ACCESS (at 0xc0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO01_PERPH_RESET_CTL1"
      sgroup "GPIO01_PERPH_RESET_CTL1 (at 0xc0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO01_PERPH_RESET_CTL2"
      sgroup "GPIO01_PERPH_RESET_CTL2 (at 0xc0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO01_PERPH_RESET_CTL3"
      sgroup "GPIO01_PERPH_RESET_CTL3 (at 0xc0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO01_PERPH_RESET_CTL4"
      sgroup "GPIO01_PERPH_RESET_CTL4 (at 0xc0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        set &access:&cmd_addr %l 0x80c0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO02"
  tree "GPIO02"
    tree "GPIO02_REVISION1"
      sgroup "GPIO02_REVISION1 (at 0xc100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO02_REVISION2"
      sgroup "GPIO02_REVISION2 (at 0xc101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO02_REVISION3"
      sgroup "GPIO02_REVISION3 (at 0xc102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO02_REVISION4"
      sgroup "GPIO02_REVISION4 (at 0xc103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO02_PERPH_TYPE"
      sgroup "GPIO02_PERPH_TYPE (at 0xc104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO02_PERPH_SUBTYPE"
      sgroup "GPIO02_PERPH_SUBTYPE (at 0xc105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO02_STATUS1"
      sgroup "GPIO02_STATUS1 (at 0xc108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO02_INT_RT_STS"
      sgroup "GPIO02_INT_RT_STS (at 0xc110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO02_INT_SET_TYPE"
      sgroup "GPIO02_INT_SET_TYPE (at 0xc111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO02_INT_POLARITY_HIGH"
      sgroup "GPIO02_INT_POLARITY_HIGH (at 0xc112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO02_INT_POLARITY_LOW"
      sgroup "GPIO02_INT_POLARITY_LOW (at 0xc113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO02_INT_LATCHED_CLR"
      sgroup "GPIO02_INT_LATCHED_CLR (at 0xc114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO02_INT_EN_SET"
      sgroup "GPIO02_INT_EN_SET (at 0xc115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO02_INT_EN_CLR"
      sgroup "GPIO02_INT_EN_CLR (at 0xc116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO02_INT_LATCHED_STS"
      sgroup "GPIO02_INT_LATCHED_STS (at 0xc118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO02_INT_PENDING_STS"
      sgroup "GPIO02_INT_PENDING_STS (at 0xc119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO02_INT_MID_SEL"
      sgroup "GPIO02_INT_MID_SEL (at 0xc11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO02_INT_PRIORITY"
      sgroup "GPIO02_INT_PRIORITY (at 0xc11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO02_MODE_CTL"
      sgroup "GPIO02_MODE_CTL (at 0xc140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO02_DIG_VIN_CTL"
      sgroup "GPIO02_DIG_VIN_CTL (at 0xc141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO02_DIG_PULL_CTL"
      sgroup "GPIO02_DIG_PULL_CTL (at 0xc142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO02_DIG_IN_DTEST_SEL"
      sgroup "GPIO02_DIG_IN_DTEST_SEL (at 0xc143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO02_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO02_DIG_OUT_SOURCE_CTL (at 0xc144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO02_DIG_OUT_DRV_CTL"
      sgroup "GPIO02_DIG_OUT_DRV_CTL (at 0xc145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO02_EN_CTL"
      sgroup "GPIO02_EN_CTL (at 0xc146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO02_ANA_PASS_THRU_SEL"
      sgroup "GPIO02_ANA_PASS_THRU_SEL (at 0xc14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO02_SEC_ACCESS"
      sgroup "GPIO02_SEC_ACCESS (at 0xc1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO02_PERPH_RESET_CTL1"
      sgroup "GPIO02_PERPH_RESET_CTL1 (at 0xc1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO02_PERPH_RESET_CTL2"
      sgroup "GPIO02_PERPH_RESET_CTL2 (at 0xc1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO02_PERPH_RESET_CTL3"
      sgroup "GPIO02_PERPH_RESET_CTL3 (at 0xc1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO02_PERPH_RESET_CTL4"
      sgroup "GPIO02_PERPH_RESET_CTL4 (at 0xc1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        set &access:&cmd_addr %l 0x80c1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO03"
  tree "GPIO03"
    tree "GPIO03_REVISION1"
      sgroup "GPIO03_REVISION1 (at 0xc200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO03_REVISION2"
      sgroup "GPIO03_REVISION2 (at 0xc201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO03_REVISION3"
      sgroup "GPIO03_REVISION3 (at 0xc202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO03_REVISION4"
      sgroup "GPIO03_REVISION4 (at 0xc203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO03_PERPH_TYPE"
      sgroup "GPIO03_PERPH_TYPE (at 0xc204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO03_PERPH_SUBTYPE"
      sgroup "GPIO03_PERPH_SUBTYPE (at 0xc205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO03_STATUS1"
      sgroup "GPIO03_STATUS1 (at 0xc208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO03_INT_RT_STS"
      sgroup "GPIO03_INT_RT_STS (at 0xc210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO03_INT_SET_TYPE"
      sgroup "GPIO03_INT_SET_TYPE (at 0xc211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO03_INT_POLARITY_HIGH"
      sgroup "GPIO03_INT_POLARITY_HIGH (at 0xc212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO03_INT_POLARITY_LOW"
      sgroup "GPIO03_INT_POLARITY_LOW (at 0xc213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO03_INT_LATCHED_CLR"
      sgroup "GPIO03_INT_LATCHED_CLR (at 0xc214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO03_INT_EN_SET"
      sgroup "GPIO03_INT_EN_SET (at 0xc215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO03_INT_EN_CLR"
      sgroup "GPIO03_INT_EN_CLR (at 0xc216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO03_INT_LATCHED_STS"
      sgroup "GPIO03_INT_LATCHED_STS (at 0xc218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO03_INT_PENDING_STS"
      sgroup "GPIO03_INT_PENDING_STS (at 0xc219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO03_INT_MID_SEL"
      sgroup "GPIO03_INT_MID_SEL (at 0xc21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO03_INT_PRIORITY"
      sgroup "GPIO03_INT_PRIORITY (at 0xc21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO03_MODE_CTL"
      sgroup "GPIO03_MODE_CTL (at 0xc240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO03_DIG_VIN_CTL"
      sgroup "GPIO03_DIG_VIN_CTL (at 0xc241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO03_DIG_PULL_CTL"
      sgroup "GPIO03_DIG_PULL_CTL (at 0xc242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO03_DIG_IN_DTEST_SEL"
      sgroup "GPIO03_DIG_IN_DTEST_SEL (at 0xc243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO03_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO03_DIG_OUT_SOURCE_CTL (at 0xc244)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO03_DIG_OUT_DRV_CTL"
      sgroup "GPIO03_DIG_OUT_DRV_CTL (at 0xc245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO03_EN_CTL"
      sgroup "GPIO03_EN_CTL (at 0xc246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO03_ANA_PASS_THRU_SEL"
      sgroup "GPIO03_ANA_PASS_THRU_SEL (at 0xc24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO03_SEC_ACCESS"
      sgroup "GPIO03_SEC_ACCESS (at 0xc2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO03_PERPH_RESET_CTL1"
      sgroup "GPIO03_PERPH_RESET_CTL1 (at 0xc2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO03_PERPH_RESET_CTL2"
      sgroup "GPIO03_PERPH_RESET_CTL2 (at 0xc2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO03_PERPH_RESET_CTL3"
      sgroup "GPIO03_PERPH_RESET_CTL3 (at 0xc2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO03_PERPH_RESET_CTL4"
      sgroup "GPIO03_PERPH_RESET_CTL4 (at 0xc2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        set &access:&cmd_addr %l 0x80c2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO04"
  tree "GPIO04"
    tree "GPIO04_REVISION1"
      sgroup "GPIO04_REVISION1 (at 0xc300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO04_REVISION2"
      sgroup "GPIO04_REVISION2 (at 0xc301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO04_REVISION3"
      sgroup "GPIO04_REVISION3 (at 0xc302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO04_REVISION4"
      sgroup "GPIO04_REVISION4 (at 0xc303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO04_PERPH_TYPE"
      sgroup "GPIO04_PERPH_TYPE (at 0xc304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO04_PERPH_SUBTYPE"
      sgroup "GPIO04_PERPH_SUBTYPE (at 0xc305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO04_STATUS1"
      sgroup "GPIO04_STATUS1 (at 0xc308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO04_INT_RT_STS"
      sgroup "GPIO04_INT_RT_STS (at 0xc310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO04_INT_SET_TYPE"
      sgroup "GPIO04_INT_SET_TYPE (at 0xc311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO04_INT_POLARITY_HIGH"
      sgroup "GPIO04_INT_POLARITY_HIGH (at 0xc312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO04_INT_POLARITY_LOW"
      sgroup "GPIO04_INT_POLARITY_LOW (at 0xc313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO04_INT_LATCHED_CLR"
      sgroup "GPIO04_INT_LATCHED_CLR (at 0xc314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO04_INT_EN_SET"
      sgroup "GPIO04_INT_EN_SET (at 0xc315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO04_INT_EN_CLR"
      sgroup "GPIO04_INT_EN_CLR (at 0xc316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO04_INT_LATCHED_STS"
      sgroup "GPIO04_INT_LATCHED_STS (at 0xc318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO04_INT_PENDING_STS"
      sgroup "GPIO04_INT_PENDING_STS (at 0xc319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO04_INT_MID_SEL"
      sgroup "GPIO04_INT_MID_SEL (at 0xc31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO04_INT_PRIORITY"
      sgroup "GPIO04_INT_PRIORITY (at 0xc31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO04_MODE_CTL"
      sgroup "GPIO04_MODE_CTL (at 0xc340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO04_DIG_VIN_CTL"
      sgroup "GPIO04_DIG_VIN_CTL (at 0xc341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO04_DIG_PULL_CTL"
      sgroup "GPIO04_DIG_PULL_CTL (at 0xc342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO04_DIG_IN_DTEST_SEL"
      sgroup "GPIO04_DIG_IN_DTEST_SEL (at 0xc343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO04_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO04_DIG_OUT_SOURCE_CTL (at 0xc344)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO04_DIG_OUT_DRV_CTL"
      sgroup "GPIO04_DIG_OUT_DRV_CTL (at 0xc345)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO04_EN_CTL"
      sgroup "GPIO04_EN_CTL (at 0xc346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO04_ANA_PASS_THRU_SEL"
      sgroup "GPIO04_ANA_PASS_THRU_SEL (at 0xc34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO04_SEC_ACCESS"
      sgroup "GPIO04_SEC_ACCESS (at 0xc3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO04_PERPH_RESET_CTL1"
      sgroup "GPIO04_PERPH_RESET_CTL1 (at 0xc3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO04_PERPH_RESET_CTL2"
      sgroup "GPIO04_PERPH_RESET_CTL2 (at 0xc3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO04_PERPH_RESET_CTL3"
      sgroup "GPIO04_PERPH_RESET_CTL3 (at 0xc3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO04_PERPH_RESET_CTL4"
      sgroup "GPIO04_PERPH_RESET_CTL4 (at 0xc3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        set &access:&cmd_addr %l 0x80c3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO05"
  tree "GPIO05"
    tree "GPIO05_REVISION1"
      sgroup "GPIO05_REVISION1 (at 0xc400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO05_REVISION2"
      sgroup "GPIO05_REVISION2 (at 0xc401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO05_REVISION3"
      sgroup "GPIO05_REVISION3 (at 0xc402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO05_REVISION4"
      sgroup "GPIO05_REVISION4 (at 0xc403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO05_PERPH_TYPE"
      sgroup "GPIO05_PERPH_TYPE (at 0xc404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO05_PERPH_SUBTYPE"
      sgroup "GPIO05_PERPH_SUBTYPE (at 0xc405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO05_STATUS1"
      sgroup "GPIO05_STATUS1 (at 0xc408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO05_INT_RT_STS"
      sgroup "GPIO05_INT_RT_STS (at 0xc410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO05_INT_SET_TYPE"
      sgroup "GPIO05_INT_SET_TYPE (at 0xc411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO05_INT_POLARITY_HIGH"
      sgroup "GPIO05_INT_POLARITY_HIGH (at 0xc412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO05_INT_POLARITY_LOW"
      sgroup "GPIO05_INT_POLARITY_LOW (at 0xc413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO05_INT_LATCHED_CLR"
      sgroup "GPIO05_INT_LATCHED_CLR (at 0xc414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO05_INT_EN_SET"
      sgroup "GPIO05_INT_EN_SET (at 0xc415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO05_INT_EN_CLR"
      sgroup "GPIO05_INT_EN_CLR (at 0xc416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO05_INT_LATCHED_STS"
      sgroup "GPIO05_INT_LATCHED_STS (at 0xc418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO05_INT_PENDING_STS"
      sgroup "GPIO05_INT_PENDING_STS (at 0xc419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO05_INT_MID_SEL"
      sgroup "GPIO05_INT_MID_SEL (at 0xc41a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO05_INT_PRIORITY"
      sgroup "GPIO05_INT_PRIORITY (at 0xc41b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c41b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc41b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO05_MODE_CTL"
      sgroup "GPIO05_MODE_CTL (at 0xc440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO05_DIG_VIN_CTL"
      sgroup "GPIO05_DIG_VIN_CTL (at 0xc441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO05_DIG_PULL_CTL"
      sgroup "GPIO05_DIG_PULL_CTL (at 0xc442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO05_DIG_IN_DTEST_SEL"
      sgroup "GPIO05_DIG_IN_DTEST_SEL (at 0xc443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO05_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO05_DIG_OUT_SOURCE_CTL (at 0xc444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO05_DIG_OUT_DRV_CTL"
      sgroup "GPIO05_DIG_OUT_DRV_CTL (at 0xc445)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO05_EN_CTL"
      sgroup "GPIO05_EN_CTL (at 0xc446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO05_ANA_PASS_THRU_SEL"
      sgroup "GPIO05_ANA_PASS_THRU_SEL (at 0xc44a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c44a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc44a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO05_SEC_ACCESS"
      sgroup "GPIO05_SEC_ACCESS (at 0xc4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO05_PERPH_RESET_CTL1"
      sgroup "GPIO05_PERPH_RESET_CTL1 (at 0xc4d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO05_PERPH_RESET_CTL2"
      sgroup "GPIO05_PERPH_RESET_CTL2 (at 0xc4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO05_PERPH_RESET_CTL3"
      sgroup "GPIO05_PERPH_RESET_CTL3 (at 0xc4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO05_PERPH_RESET_CTL4"
      sgroup "GPIO05_PERPH_RESET_CTL4 (at 0xc4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        set &access:&cmd_addr %l 0x80c4db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO06"
  tree "GPIO06"
    tree "GPIO06_REVISION1"
      sgroup "GPIO06_REVISION1 (at 0xc500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO06_REVISION2"
      sgroup "GPIO06_REVISION2 (at 0xc501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO06_REVISION3"
      sgroup "GPIO06_REVISION3 (at 0xc502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO06_REVISION4"
      sgroup "GPIO06_REVISION4 (at 0xc503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO06_PERPH_TYPE"
      sgroup "GPIO06_PERPH_TYPE (at 0xc504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO06_PERPH_SUBTYPE"
      sgroup "GPIO06_PERPH_SUBTYPE (at 0xc505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO06_STATUS1"
      sgroup "GPIO06_STATUS1 (at 0xc508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO06_INT_RT_STS"
      sgroup "GPIO06_INT_RT_STS (at 0xc510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO06_INT_SET_TYPE"
      sgroup "GPIO06_INT_SET_TYPE (at 0xc511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO06_INT_POLARITY_HIGH"
      sgroup "GPIO06_INT_POLARITY_HIGH (at 0xc512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO06_INT_POLARITY_LOW"
      sgroup "GPIO06_INT_POLARITY_LOW (at 0xc513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO06_INT_LATCHED_CLR"
      sgroup "GPIO06_INT_LATCHED_CLR (at 0xc514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO06_INT_EN_SET"
      sgroup "GPIO06_INT_EN_SET (at 0xc515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO06_INT_EN_CLR"
      sgroup "GPIO06_INT_EN_CLR (at 0xc516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO06_INT_LATCHED_STS"
      sgroup "GPIO06_INT_LATCHED_STS (at 0xc518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO06_INT_PENDING_STS"
      sgroup "GPIO06_INT_PENDING_STS (at 0xc519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO06_INT_MID_SEL"
      sgroup "GPIO06_INT_MID_SEL (at 0xc51a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO06_INT_PRIORITY"
      sgroup "GPIO06_INT_PRIORITY (at 0xc51b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c51b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc51b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO06_MODE_CTL"
      sgroup "GPIO06_MODE_CTL (at 0xc540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO06_DIG_VIN_CTL"
      sgroup "GPIO06_DIG_VIN_CTL (at 0xc541)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO06_DIG_PULL_CTL"
      sgroup "GPIO06_DIG_PULL_CTL (at 0xc542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO06_DIG_IN_DTEST_SEL"
      sgroup "GPIO06_DIG_IN_DTEST_SEL (at 0xc543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO06_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO06_DIG_OUT_SOURCE_CTL (at 0xc544)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO06_DIG_OUT_DRV_CTL"
      sgroup "GPIO06_DIG_OUT_DRV_CTL (at 0xc545)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO06_EN_CTL"
      sgroup "GPIO06_EN_CTL (at 0xc546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO06_ANA_PASS_THRU_SEL"
      sgroup "GPIO06_ANA_PASS_THRU_SEL (at 0xc54a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c54a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc54a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO06_SEC_ACCESS"
      sgroup "GPIO06_SEC_ACCESS (at 0xc5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO06_PERPH_RESET_CTL1"
      sgroup "GPIO06_PERPH_RESET_CTL1 (at 0xc5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO06_PERPH_RESET_CTL2"
      sgroup "GPIO06_PERPH_RESET_CTL2 (at 0xc5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO06_PERPH_RESET_CTL3"
      sgroup "GPIO06_PERPH_RESET_CTL3 (at 0xc5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO06_PERPH_RESET_CTL4"
      sgroup "GPIO06_PERPH_RESET_CTL4 (at 0xc5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        set &access:&cmd_addr %l 0x80c5db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO07"
  tree "GPIO07"
    tree "GPIO07_REVISION1"
      sgroup "GPIO07_REVISION1 (at 0xc600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO07_REVISION2"
      sgroup "GPIO07_REVISION2 (at 0xc601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO07_REVISION3"
      sgroup "GPIO07_REVISION3 (at 0xc602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO07_REVISION4"
      sgroup "GPIO07_REVISION4 (at 0xc603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO07_PERPH_TYPE"
      sgroup "GPIO07_PERPH_TYPE (at 0xc604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO07_PERPH_SUBTYPE"
      sgroup "GPIO07_PERPH_SUBTYPE (at 0xc605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO07_STATUS1"
      sgroup "GPIO07_STATUS1 (at 0xc608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO07_INT_RT_STS"
      sgroup "GPIO07_INT_RT_STS (at 0xc610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO07_INT_SET_TYPE"
      sgroup "GPIO07_INT_SET_TYPE (at 0xc611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO07_INT_POLARITY_HIGH"
      sgroup "GPIO07_INT_POLARITY_HIGH (at 0xc612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO07_INT_POLARITY_LOW"
      sgroup "GPIO07_INT_POLARITY_LOW (at 0xc613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO07_INT_LATCHED_CLR"
      sgroup "GPIO07_INT_LATCHED_CLR (at 0xc614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO07_INT_EN_SET"
      sgroup "GPIO07_INT_EN_SET (at 0xc615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO07_INT_EN_CLR"
      sgroup "GPIO07_INT_EN_CLR (at 0xc616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO07_INT_LATCHED_STS"
      sgroup "GPIO07_INT_LATCHED_STS (at 0xc618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO07_INT_PENDING_STS"
      sgroup "GPIO07_INT_PENDING_STS (at 0xc619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO07_INT_MID_SEL"
      sgroup "GPIO07_INT_MID_SEL (at 0xc61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c61a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO07_INT_PRIORITY"
      sgroup "GPIO07_INT_PRIORITY (at 0xc61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c61b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO07_MODE_CTL"
      sgroup "GPIO07_MODE_CTL (at 0xc640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO07_DIG_VIN_CTL"
      sgroup "GPIO07_DIG_VIN_CTL (at 0xc641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO07_DIG_PULL_CTL"
      sgroup "GPIO07_DIG_PULL_CTL (at 0xc642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO07_DIG_IN_DTEST_SEL"
      sgroup "GPIO07_DIG_IN_DTEST_SEL (at 0xc643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO07_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO07_DIG_OUT_SOURCE_CTL (at 0xc644)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO07_DIG_OUT_DRV_CTL"
      sgroup "GPIO07_DIG_OUT_DRV_CTL (at 0xc645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO07_EN_CTL"
      sgroup "GPIO07_EN_CTL (at 0xc646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO07_ANA_PASS_THRU_SEL"
      sgroup "GPIO07_ANA_PASS_THRU_SEL (at 0xc64a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c64a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc64a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO07_SEC_ACCESS"
      sgroup "GPIO07_SEC_ACCESS (at 0xc6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO07_PERPH_RESET_CTL1"
      sgroup "GPIO07_PERPH_RESET_CTL1 (at 0xc6d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO07_PERPH_RESET_CTL2"
      sgroup "GPIO07_PERPH_RESET_CTL2 (at 0xc6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO07_PERPH_RESET_CTL3"
      sgroup "GPIO07_PERPH_RESET_CTL3 (at 0xc6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO07_PERPH_RESET_CTL4"
      sgroup "GPIO07_PERPH_RESET_CTL4 (at 0xc6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        set &access:&cmd_addr %l 0x80c6db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO08"
  tree "GPIO08"
    tree "GPIO08_REVISION1"
      sgroup "GPIO08_REVISION1 (at 0xc700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO08_REVISION2"
      sgroup "GPIO08_REVISION2 (at 0xc701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO08_REVISION3"
      sgroup "GPIO08_REVISION3 (at 0xc702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO08_REVISION4"
      sgroup "GPIO08_REVISION4 (at 0xc703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO08_PERPH_TYPE"
      sgroup "GPIO08_PERPH_TYPE (at 0xc704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO08_PERPH_SUBTYPE"
      sgroup "GPIO08_PERPH_SUBTYPE (at 0xc705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO08_STATUS1"
      sgroup "GPIO08_STATUS1 (at 0xc708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO08_INT_RT_STS"
      sgroup "GPIO08_INT_RT_STS (at 0xc710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO08_INT_SET_TYPE"
      sgroup "GPIO08_INT_SET_TYPE (at 0xc711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO08_INT_POLARITY_HIGH"
      sgroup "GPIO08_INT_POLARITY_HIGH (at 0xc712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO08_INT_POLARITY_LOW"
      sgroup "GPIO08_INT_POLARITY_LOW (at 0xc713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO08_INT_LATCHED_CLR"
      sgroup "GPIO08_INT_LATCHED_CLR (at 0xc714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO08_INT_EN_SET"
      sgroup "GPIO08_INT_EN_SET (at 0xc715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO08_INT_EN_CLR"
      sgroup "GPIO08_INT_EN_CLR (at 0xc716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO08_INT_LATCHED_STS"
      sgroup "GPIO08_INT_LATCHED_STS (at 0xc718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO08_INT_PENDING_STS"
      sgroup "GPIO08_INT_PENDING_STS (at 0xc719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO08_INT_MID_SEL"
      sgroup "GPIO08_INT_MID_SEL (at 0xc71a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c71a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc71a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO08_INT_PRIORITY"
      sgroup "GPIO08_INT_PRIORITY (at 0xc71b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c71b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc71b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO08_MODE_CTL"
      sgroup "GPIO08_MODE_CTL (at 0xc740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO08_DIG_VIN_CTL"
      sgroup "GPIO08_DIG_VIN_CTL (at 0xc741)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO08_DIG_PULL_CTL"
      sgroup "GPIO08_DIG_PULL_CTL (at 0xc742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO08_DIG_IN_DTEST_SEL"
      sgroup "GPIO08_DIG_IN_DTEST_SEL (at 0xc743)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO08_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO08_DIG_OUT_SOURCE_CTL (at 0xc744)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO08_DIG_OUT_DRV_CTL"
      sgroup "GPIO08_DIG_OUT_DRV_CTL (at 0xc745)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO08_EN_CTL"
      sgroup "GPIO08_EN_CTL (at 0xc746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO08_ANA_PASS_THRU_SEL"
      sgroup "GPIO08_ANA_PASS_THRU_SEL (at 0xc74a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c74a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc74a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO08_SEC_ACCESS"
      sgroup "GPIO08_SEC_ACCESS (at 0xc7d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO08_PERPH_RESET_CTL1"
      sgroup "GPIO08_PERPH_RESET_CTL1 (at 0xc7d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO08_PERPH_RESET_CTL2"
      sgroup "GPIO08_PERPH_RESET_CTL2 (at 0xc7d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO08_PERPH_RESET_CTL3"
      sgroup "GPIO08_PERPH_RESET_CTL3 (at 0xc7da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO08_PERPH_RESET_CTL4"
      sgroup "GPIO08_PERPH_RESET_CTL4 (at 0xc7db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        set &access:&cmd_addr %l 0x80c7db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc7db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO09"
  tree "GPIO09"
    tree "GPIO09_REVISION1"
      sgroup "GPIO09_REVISION1 (at 0xc800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO09_REVISION2"
      sgroup "GPIO09_REVISION2 (at 0xc801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO09_REVISION3"
      sgroup "GPIO09_REVISION3 (at 0xc802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO09_REVISION4"
      sgroup "GPIO09_REVISION4 (at 0xc803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO09_PERPH_TYPE"
      sgroup "GPIO09_PERPH_TYPE (at 0xc804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO09_PERPH_SUBTYPE"
      sgroup "GPIO09_PERPH_SUBTYPE (at 0xc805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO09_STATUS1"
      sgroup "GPIO09_STATUS1 (at 0xc808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO09_INT_RT_STS"
      sgroup "GPIO09_INT_RT_STS (at 0xc810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO09_INT_SET_TYPE"
      sgroup "GPIO09_INT_SET_TYPE (at 0xc811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO09_INT_POLARITY_HIGH"
      sgroup "GPIO09_INT_POLARITY_HIGH (at 0xc812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO09_INT_POLARITY_LOW"
      sgroup "GPIO09_INT_POLARITY_LOW (at 0xc813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO09_INT_LATCHED_CLR"
      sgroup "GPIO09_INT_LATCHED_CLR (at 0xc814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO09_INT_EN_SET"
      sgroup "GPIO09_INT_EN_SET (at 0xc815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO09_INT_EN_CLR"
      sgroup "GPIO09_INT_EN_CLR (at 0xc816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO09_INT_LATCHED_STS"
      sgroup "GPIO09_INT_LATCHED_STS (at 0xc818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO09_INT_PENDING_STS"
      sgroup "GPIO09_INT_PENDING_STS (at 0xc819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO09_INT_MID_SEL"
      sgroup "GPIO09_INT_MID_SEL (at 0xc81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c81a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO09_INT_PRIORITY"
      sgroup "GPIO09_INT_PRIORITY (at 0xc81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c81b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO09_MODE_CTL"
      sgroup "GPIO09_MODE_CTL (at 0xc840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO09_DIG_VIN_CTL"
      sgroup "GPIO09_DIG_VIN_CTL (at 0xc841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO09_DIG_PULL_CTL"
      sgroup "GPIO09_DIG_PULL_CTL (at 0xc842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO09_DIG_IN_DTEST_SEL"
      sgroup "GPIO09_DIG_IN_DTEST_SEL (at 0xc843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO09_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO09_DIG_OUT_SOURCE_CTL (at 0xc844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO09_DIG_OUT_DRV_CTL"
      sgroup "GPIO09_DIG_OUT_DRV_CTL (at 0xc845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO09_EN_CTL"
      sgroup "GPIO09_EN_CTL (at 0xc846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO09_ANA_PASS_THRU_SEL"
      sgroup "GPIO09_ANA_PASS_THRU_SEL (at 0xc84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c84a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO09_SEC_ACCESS"
      sgroup "GPIO09_SEC_ACCESS (at 0xc8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO09_PERPH_RESET_CTL1"
      sgroup "GPIO09_PERPH_RESET_CTL1 (at 0xc8d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO09_PERPH_RESET_CTL2"
      sgroup "GPIO09_PERPH_RESET_CTL2 (at 0xc8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO09_PERPH_RESET_CTL3"
      sgroup "GPIO09_PERPH_RESET_CTL3 (at 0xc8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO09_PERPH_RESET_CTL4"
      sgroup "GPIO09_PERPH_RESET_CTL4 (at 0xc8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        set &access:&cmd_addr %l 0x80c8db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO10"
  tree "GPIO10"
    tree "GPIO10_REVISION1"
      sgroup "GPIO10_REVISION1 (at 0xc900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION2"
      sgroup "GPIO10_REVISION2 (at 0xc901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO10_REVISION3"
      sgroup "GPIO10_REVISION3 (at 0xc902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO10_REVISION4"
      sgroup "GPIO10_REVISION4 (at 0xc903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO10_PERPH_TYPE"
      sgroup "GPIO10_PERPH_TYPE (at 0xc904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO10_PERPH_SUBTYPE"
      sgroup "GPIO10_PERPH_SUBTYPE (at 0xc905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO10_STATUS1"
      sgroup "GPIO10_STATUS1 (at 0xc908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO10_INT_RT_STS"
      sgroup "GPIO10_INT_RT_STS (at 0xc910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO10_INT_SET_TYPE"
      sgroup "GPIO10_INT_SET_TYPE (at 0xc911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO10_INT_POLARITY_HIGH"
      sgroup "GPIO10_INT_POLARITY_HIGH (at 0xc912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_POLARITY_LOW"
      sgroup "GPIO10_INT_POLARITY_LOW (at 0xc913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_CLR"
      sgroup "GPIO10_INT_LATCHED_CLR (at 0xc914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO10_INT_EN_SET"
      sgroup "GPIO10_INT_EN_SET (at 0xc915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_EN_CLR"
      sgroup "GPIO10_INT_EN_CLR (at 0xc916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO10_INT_LATCHED_STS"
      sgroup "GPIO10_INT_LATCHED_STS (at 0xc918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO10_INT_PENDING_STS"
      sgroup "GPIO10_INT_PENDING_STS (at 0xc919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO10_INT_MID_SEL"
      sgroup "GPIO10_INT_MID_SEL (at 0xc91a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c91a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc91a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO10_INT_PRIORITY"
      sgroup "GPIO10_INT_PRIORITY (at 0xc91b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c91b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc91b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO10_MODE_CTL"
      sgroup "GPIO10_MODE_CTL (at 0xc940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO10_DIG_VIN_CTL"
      sgroup "GPIO10_DIG_VIN_CTL (at 0xc941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO10_DIG_PULL_CTL"
      sgroup "GPIO10_DIG_PULL_CTL (at 0xc942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO10_DIG_IN_DTEST_SEL"
      sgroup "GPIO10_DIG_IN_DTEST_SEL (at 0xc943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO10_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO10_DIG_OUT_SOURCE_CTL (at 0xc944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO10_DIG_OUT_DRV_CTL"
      sgroup "GPIO10_DIG_OUT_DRV_CTL (at 0xc945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO10_EN_CTL"
      sgroup "GPIO10_EN_CTL (at 0xc946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO10_ANA_PASS_THRU_SEL"
      sgroup "GPIO10_ANA_PASS_THRU_SEL (at 0xc94a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c94a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO10_SEC_ACCESS"
      sgroup "GPIO10_SEC_ACCESS (at 0xc9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO10_PERPH_RESET_CTL1"
      sgroup "GPIO10_PERPH_RESET_CTL1 (at 0xc9d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL2"
      sgroup "GPIO10_PERPH_RESET_CTL2 (at 0xc9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL3"
      sgroup "GPIO10_PERPH_RESET_CTL3 (at 0xc9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO10_PERPH_RESET_CTL4"
      sgroup "GPIO10_PERPH_RESET_CTL4 (at 0xc9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        set &access:&cmd_addr %l 0x80c9db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO11"
  tree "GPIO11"
    tree "GPIO11_REVISION1"
      sgroup "GPIO11_REVISION1 (at 0xca00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO11_REVISION2"
      sgroup "GPIO11_REVISION2 (at 0xca01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO11_REVISION3"
      sgroup "GPIO11_REVISION3 (at 0xca02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO11_REVISION4"
      sgroup "GPIO11_REVISION4 (at 0xca03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO11_PERPH_TYPE"
      sgroup "GPIO11_PERPH_TYPE (at 0xca04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO11_PERPH_SUBTYPE"
      sgroup "GPIO11_PERPH_SUBTYPE (at 0xca05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO11_STATUS1"
      sgroup "GPIO11_STATUS1 (at 0xca08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO11_INT_RT_STS"
      sgroup "GPIO11_INT_RT_STS (at 0xca10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO11_INT_SET_TYPE"
      sgroup "GPIO11_INT_SET_TYPE (at 0xca11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO11_INT_POLARITY_HIGH"
      sgroup "GPIO11_INT_POLARITY_HIGH (at 0xca12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO11_INT_POLARITY_LOW"
      sgroup "GPIO11_INT_POLARITY_LOW (at 0xca13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO11_INT_LATCHED_CLR"
      sgroup "GPIO11_INT_LATCHED_CLR (at 0xca14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO11_INT_EN_SET"
      sgroup "GPIO11_INT_EN_SET (at 0xca15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO11_INT_EN_CLR"
      sgroup "GPIO11_INT_EN_CLR (at 0xca16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO11_INT_LATCHED_STS"
      sgroup "GPIO11_INT_LATCHED_STS (at 0xca18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO11_INT_PENDING_STS"
      sgroup "GPIO11_INT_PENDING_STS (at 0xca19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO11_INT_MID_SEL"
      sgroup "GPIO11_INT_MID_SEL (at 0xca1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO11_INT_PRIORITY"
      sgroup "GPIO11_INT_PRIORITY (at 0xca1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO11_MODE_CTL"
      sgroup "GPIO11_MODE_CTL (at 0xca40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO11_DIG_VIN_CTL"
      sgroup "GPIO11_DIG_VIN_CTL (at 0xca41)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO11_DIG_PULL_CTL"
      sgroup "GPIO11_DIG_PULL_CTL (at 0xca42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO11_DIG_IN_DTEST_SEL"
      sgroup "GPIO11_DIG_IN_DTEST_SEL (at 0xca43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO11_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO11_DIG_OUT_SOURCE_CTL (at 0xca44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO11_DIG_OUT_DRV_CTL"
      sgroup "GPIO11_DIG_OUT_DRV_CTL (at 0xca45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO11_EN_CTL"
      sgroup "GPIO11_EN_CTL (at 0xca46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO11_ANA_PASS_THRU_SEL"
      sgroup "GPIO11_ANA_PASS_THRU_SEL (at 0xca4a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80ca4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xca4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO11_SEC_ACCESS"
      sgroup "GPIO11_SEC_ACCESS (at 0xcad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO11_PERPH_RESET_CTL1"
      sgroup "GPIO11_PERPH_RESET_CTL1 (at 0xcad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL2"
      sgroup "GPIO11_PERPH_RESET_CTL2 (at 0xcad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL3"
      sgroup "GPIO11_PERPH_RESET_CTL3 (at 0xcada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO11_PERPH_RESET_CTL4"
      sgroup "GPIO11_PERPH_RESET_CTL4 (at 0xcadb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        set &access:&cmd_addr %l 0x80cadb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xca00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "GPIO12"
  tree "GPIO12"
    tree "GPIO12_REVISION1"
      sgroup "GPIO12_REVISION1 (at 0xcb00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "GPIO12_REVISION2"
      sgroup "GPIO12_REVISION2 (at 0xcb01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "GPIO12_REVISION3"
      sgroup "GPIO12_REVISION3 (at 0xcb02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "GPIO12_REVISION4"
      sgroup "GPIO12_REVISION4 (at 0xcb03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "GPIO12_PERPH_TYPE"
      sgroup "GPIO12_PERPH_TYPE (at 0xcb04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "GPIO12_PERPH_SUBTYPE"
      sgroup "GPIO12_PERPH_SUBTYPE (at 0xcb05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "GPIO12_STATUS1"
      sgroup "GPIO12_STATUS1 (at 0xcb08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GPIO_OK                                  = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_VAL                                 = " "0 (GPIO_INPUT_LOW),1 (GPIO_INPUT_HIGH)"
    tree.end
    tree "GPIO12_INT_RT_STS"
      sgroup "GPIO12_INT_RT_STS (at 0xcb10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_STS                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "GPIO12_INT_SET_TYPE"
      sgroup "GPIO12_INT_SET_TYPE (at 0xcb11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_TYPE                             = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "GPIO12_INT_POLARITY_HIGH"
      sgroup "GPIO12_INT_POLARITY_HIGH (at 0xcb12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_HIGH                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO12_INT_POLARITY_LOW"
      sgroup "GPIO12_INT_POLARITY_LOW (at 0xcb13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LOW                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "GPIO12_INT_LATCHED_CLR"
      sgroup "GPIO12_INT_LATCHED_CLR (at 0xcb14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "GPIO12_INT_EN_SET"
      sgroup "GPIO12_INT_EN_SET (at 0xcb15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_SET                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO12_INT_EN_CLR"
      sgroup "GPIO12_INT_EN_CLR (at 0xcb16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_EN_CLR                           = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "GPIO12_INT_LATCHED_STS"
      sgroup "GPIO12_INT_LATCHED_STS (at 0xcb18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_LATCHED_STS                      = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "GPIO12_INT_PENDING_STS"
      sgroup "GPIO12_INT_PENDING_STS (at 0xcb19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPIO_IN_PENDING_STS                      = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "GPIO12_INT_MID_SEL"
      sgroup "GPIO12_INT_MID_SEL (at 0xcb1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "GPIO12_INT_PRIORITY"
      sgroup "GPIO12_INT_PRIORITY (at 0xcb1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "GPIO12_MODE_CTL"
      sgroup "GPIO12_MODE_CTL (at 0xcb40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE                                     = " "0 (DIG_IN),1 (DIG_OUT),2 (DIG_INOUT),3 (ANA_PASS_THRU)"
    tree.end
    tree "GPIO12_DIG_VIN_CTL"
      sgroup "GPIO12_DIG_VIN_CTL (at 0xcb41)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0 (VIN0),1 (VIN1),2 (RESERVED2),3 (RESERVED3),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO12_DIG_PULL_CTL"
      sgroup "GPIO12_DIG_PULL_CTL (at 0xcb42)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0 (PULLUP_30UA),1 (PULLUP_1P5UA),2 (PULLUP_31P5UA),3 (PULLUP_1P5UA_30UA_BOOST),4 (PULLDOWN_10UA),5 (NO_PULL),6 (RESERVED),7 (reserved)"
    tree.end
    tree "GPIO12_DIG_IN_DTEST_SEL"
      sgroup "GPIO12_DIG_IN_DTEST_SEL (at 0xcb43)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_EN                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (RESERVED4),5 (RESERVED5),6 (RESERVED6),7 (RESERVED7)"
    tree.end
    tree "GPIO12_DIG_OUT_SOURCE_CTL"
      sgroup "GPIO12_DIG_OUT_SOURCE_CTL (at 0xcb44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OUTPUT_INVERT                            = " "0 (NO_INVERT),1 (INVERT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   OUTPUT_SOURCE_SEL                        = "
    tree.end
    tree "GPIO12_DIG_OUT_DRV_CTL"
      sgroup "GPIO12_DIG_OUT_DRV_CTL (at 0xcb45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPUT_TYPE                              = " "0 (CMOS),1 (OPEN_DRAIN_NMOS),2 (OPEN_DRAIN_PMOS),3 (NO_DRIVE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPUT_DRV_SEL                           = " "0 (RESERVED),1 (LOW_STR),2 (MED_STR),3 (HIGH_STR)"
    tree.end
    tree "GPIO12_EN_CTL"
      sgroup "GPIO12_EN_CTL (at 0xcb46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (GPIO_DISABLED),1 (GPIO_ENABLED)"
    tree.end
    tree "GPIO12_ANA_PASS_THRU_SEL"
      sgroup "GPIO12_ANA_PASS_THRU_SEL (at 0xcb4a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cb4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcb4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST_SEL                                = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "GPIO12_SEC_ACCESS"
      sgroup "GPIO12_SEC_ACCESS (at 0xcbd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "GPIO12_PERPH_RESET_CTL1"
      sgroup "GPIO12_PERPH_RESET_CTL1 (at 0xcbd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL2"
      sgroup "GPIO12_PERPH_RESET_CTL2 (at 0xcbd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL3"
      sgroup "GPIO12_PERPH_RESET_CTL3 (at 0xcbda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "GPIO12_PERPH_RESET_CTL4"
      sgroup "GPIO12_PERPH_RESET_CTL4 (at 0xcbdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        set &access:&cmd_addr %l 0x80cbdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xcb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcbdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "LDO01"
  tree "LDO01"
    tree "LDO01_REVISION1"
      sgroup "LDO01_REVISION1 (at 0x14000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO01_REVISION2"
      sgroup "LDO01_REVISION2 (at 0x14001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO01_REVISION3"
      sgroup "LDO01_REVISION3 (at 0x14002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO01_REVISION4"
      sgroup "LDO01_REVISION4 (at 0x14003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO01_PERPH_TYPE"
      sgroup "LDO01_PERPH_TYPE (at 0x14004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO01_PERPH_SUBTYPE"
      sgroup "LDO01_PERPH_SUBTYPE (at 0x14005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO01_STATUS1"
      sgroup "LDO01_STATUS1 (at 0x14008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO01_STATUS3"
      sgroup "LDO01_STATUS3 (at 0x1400a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO01_STATUS4"
      sgroup "LDO01_STATUS4 (at 0x1400b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80400b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x400b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO01_INT_RT_STS"
      sgroup "LDO01_INT_RT_STS (at 0x14010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO01_INT_SET_TYPE"
      sgroup "LDO01_INT_SET_TYPE (at 0x14011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO01_INT_POLARITY_HIGH"
      sgroup "LDO01_INT_POLARITY_HIGH (at 0x14012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO01_INT_POLARITY_LOW"
      sgroup "LDO01_INT_POLARITY_LOW (at 0x14013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO01_INT_LATCHED_CLR"
      sgroup "LDO01_INT_LATCHED_CLR (at 0x14014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO01_INT_EN_SET"
      sgroup "LDO01_INT_EN_SET (at 0x14015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO01_INT_EN_CLR"
      sgroup "LDO01_INT_EN_CLR (at 0x14016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO01_INT_LATCHED_STS"
      sgroup "LDO01_INT_LATCHED_STS (at 0x14018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO01_INT_PENDING_STS"
      sgroup "LDO01_INT_PENDING_STS (at 0x14019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO01_INT_MID_SEL"
      sgroup "LDO01_INT_MID_SEL (at 0x1401a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO01_INT_PRIORITY"
      sgroup "LDO01_INT_PRIORITY (at 0x1401b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80401b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x401b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO01_VSET_LB"
      sgroup "LDO01_VSET_LB (at 0x14040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO01_VSET_UB"
      sgroup "LDO01_VSET_UB (at 0x14041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO01_VSET_VALID_LB"
      sgroup "LDO01_VSET_VALID_LB (at 0x14042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO01_VSET_VALID_UB"
      sgroup "LDO01_VSET_VALID_UB (at 0x14043)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO01_MODE_CTL1"
      sgroup "LDO01_MODE_CTL1 (at 0x14045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO01_EN_CTL"
      sgroup "LDO01_EN_CTL (at 0x14046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO01_FOLLOW_HWEN"
      sgroup "LDO01_FOLLOW_HWEN (at 0x14047)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO01_PD_CTL"
      sgroup "LDO01_PD_CTL (at 0x14048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO01_MODE_CTL2"
      sgroup "LDO01_MODE_CTL2 (at 0x14049)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO01_RETENTION_CTL1"
      sgroup "LDO01_RETENTION_CTL1 (at 0x1404a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x80404a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x404a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RET_HYST_HIGH                            = " "0 (VSET),1 (VSET_PLUS_2LSB),2 (VSET_PLUS_4LSB),3 (VSET_PLUS_6LSB)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RET_HYST_LOW                             = " "0 (VSET_ADD_0),1 (VSET_ADD_1),2 (VSET_ADD_2),3 (VSET_ADD_3)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RET_PULSE_EN                             = " "0 (RET_PULSE_DIS),1 (RET_PULSE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RET_PULSE_WIDTH                          = " "0 (RET_PULSE_WIDTH_10US),1 (RET_PULSE_WIDTH_5US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RET_CP_CAP_SIZE                          = " "0 (X1),1 (X1P5),2 (X2P5),3 (X4P5)"
    tree.end
    tree "LDO01_CONFIG_CTL1"
      sgroup "LDO01_CONFIG_CTL1 (at 0x14052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LV_BUFFER_EN                             = " "0 (LV_BUFFER_DISABLED),1 (LV_BUFFER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AMP_BIAS_TURBO                           = " "0 (AMP_BIAS_TURBO_DIS),1 (AMP_BIAS_TURBO_EN)"
    tree.end
    tree "LDO01_BYPASS_CTL1"
      sgroup "LDO01_BYPASS_CTL1 (at 0x14053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO01_BYPASS_CTL2"
      sgroup "LDO01_BYPASS_CTL2 (at 0x14054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO01_STEPPER_CTL"
      sgroup "LDO01_STEPPER_CTL (at 0x14061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_DELAY                               = " "0 (DELAY_2_CLK),1 (DELAY_4_CLK),2 (DELAY_8_CLK),3 (DELAY_16_CLK)"
    tree.end
    tree "LDO01_OCP_CTL1"
      sgroup "LDO01_OCP_CTL1 (at 0x14066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO01_ULS_VSET_LB"
      sgroup "LDO01_ULS_VSET_LB (at 0x14068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO01_ULS_VSET_UB"
      sgroup "LDO01_ULS_VSET_UB (at 0x14069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO01_STATUS_DEB_CTL"
      sgroup "LDO01_STATUS_DEB_CTL (at 0x14070)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO01_ECM_EN_CTL"
      sgroup "LDO01_ECM_EN_CTL (at 0x14080)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO01_ECM_CONFIG"
      sgroup "LDO01_ECM_CONFIG (at 0x14081)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO01_ECM_DATA_LB"
      sgroup "LDO01_ECM_DATA_LB (at 0x14084)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO01_ECM_DATA_UB"
      sgroup "LDO01_ECM_DATA_UB (at 0x14085)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO01_SEC_ACCESS"
      sgroup "LDO01_SEC_ACCESS (at 0x140d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO01_PERPH_RESET_CTL1"
      sgroup "LDO01_PERPH_RESET_CTL1 (at 0x140d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO01_PERPH_RESET_CTL2"
      sgroup "LDO01_PERPH_RESET_CTL2 (at 0x140d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO01_PERPH_RESET_CTL3"
      sgroup "LDO01_PERPH_RESET_CTL3 (at 0x140da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO01_PERPH_RESET_CTL4"
      sgroup "LDO01_PERPH_RESET_CTL4 (at 0x140db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO01_INT_TEST1"
      sgroup "LDO01_INT_TEST1 (at 0x140e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO01_INT_TEST_VAL"
      sgroup "LDO01_INT_TEST_VAL (at 0x140e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO01_TEST1"
      sgroup "LDO01_TEST1 (at 0x140e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO01_TEST2"
      sgroup "LDO01_TEST2 (at 0x140e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (STEPPER_DONE_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (D_D2A_LDO_VSET_DO_2_0),5 (D_A2D_RM_VREG_OK_DI_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (D_D2A_RET_MODE_EN_DO_D_A2D_RM_READY_DI_D_D2A_AMP_EN_DO),7 (D_A2D_RM_DISCHARGE_STS_DI_D_A2D_RM_CHARGE_STS_DI_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO01_TEST3"
      sgroup "LDO01_TEST3 (at 0x140e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_SELECT                                = " "0 (STEPPING_IN_SOFTSTART_EN),1 (STEPPING_IN_SOFTSTART_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO01_ECM_TEST1"
      sgroup "LDO01_ECM_TEST1 (at 0x140e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO01_ECM_TEST2"
      sgroup "LDO01_ECM_TEST2 (at 0x140e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO01_TRIM_NUM"
      sgroup "LDO01_TRIM_NUM (at 0x140f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO01_TRIM_CTRL"
      sgroup "LDO01_TRIM_CTRL (at 0x140f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
    tree "LDO01_RM_TRIM_CTRL"
      sgroup "LDO01_RM_TRIM_CTRL (at 0x140f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        set &access:&cmd_addr %l 0x8040f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x40f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RM_TRIM_CTRL                             = "
    tree.end
  tree.end
tree.end
tree "LDO02"
  tree "LDO02"
    tree "LDO02_REVISION1"
      sgroup "LDO02_REVISION1 (at 0x14100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO02_REVISION2"
      sgroup "LDO02_REVISION2 (at 0x14101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO02_REVISION3"
      sgroup "LDO02_REVISION3 (at 0x14102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO02_REVISION4"
      sgroup "LDO02_REVISION4 (at 0x14103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO02_PERPH_TYPE"
      sgroup "LDO02_PERPH_TYPE (at 0x14104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO02_PERPH_SUBTYPE"
      sgroup "LDO02_PERPH_SUBTYPE (at 0x14105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO02_STATUS1"
      sgroup "LDO02_STATUS1 (at 0x14108)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO02_STATUS3"
      sgroup "LDO02_STATUS3 (at 0x1410a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80410a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x410a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO02_STATUS4"
      sgroup "LDO02_STATUS4 (at 0x1410b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80410b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x410b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO02_INT_RT_STS"
      sgroup "LDO02_INT_RT_STS (at 0x14110)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO02_INT_SET_TYPE"
      sgroup "LDO02_INT_SET_TYPE (at 0x14111)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO02_INT_POLARITY_HIGH"
      sgroup "LDO02_INT_POLARITY_HIGH (at 0x14112)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO02_INT_POLARITY_LOW"
      sgroup "LDO02_INT_POLARITY_LOW (at 0x14113)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO02_INT_LATCHED_CLR"
      sgroup "LDO02_INT_LATCHED_CLR (at 0x14114)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO02_INT_EN_SET"
      sgroup "LDO02_INT_EN_SET (at 0x14115)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO02_INT_EN_CLR"
      sgroup "LDO02_INT_EN_CLR (at 0x14116)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO02_INT_LATCHED_STS"
      sgroup "LDO02_INT_LATCHED_STS (at 0x14118)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO02_INT_PENDING_STS"
      sgroup "LDO02_INT_PENDING_STS (at 0x14119)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO02_INT_MID_SEL"
      sgroup "LDO02_INT_MID_SEL (at 0x1411a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO02_INT_PRIORITY"
      sgroup "LDO02_INT_PRIORITY (at 0x1411b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80411b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x411b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO02_VSET_LB"
      sgroup "LDO02_VSET_LB (at 0x14140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO02_VSET_UB"
      sgroup "LDO02_VSET_UB (at 0x14141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO02_VSET_VALID_LB"
      sgroup "LDO02_VSET_VALID_LB (at 0x14142)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO02_VSET_VALID_UB"
      sgroup "LDO02_VSET_VALID_UB (at 0x14143)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO02_MODE_CTL1"
      sgroup "LDO02_MODE_CTL1 (at 0x14145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO02_EN_CTL"
      sgroup "LDO02_EN_CTL (at 0x14146)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO02_FOLLOW_HWEN"
      sgroup "LDO02_FOLLOW_HWEN (at 0x14147)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO02_PD_CTL"
      sgroup "LDO02_PD_CTL (at 0x14148)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO02_MODE_CTL2"
      sgroup "LDO02_MODE_CTL2 (at 0x14149)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO02_RETENTION_CTL1"
      sgroup "LDO02_RETENTION_CTL1 (at 0x1414a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x80414a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x414a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RET_HYST_HIGH                            = " "0 (VSET),1 (VSET_PLUS_2LSB),2 (VSET_PLUS_4LSB),3 (VSET_PLUS_6LSB)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RET_HYST_LOW                             = " "0 (VSET_ADD_0),1 (VSET_ADD_1),2 (VSET_ADD_2),3 (VSET_ADD_3)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RET_PULSE_EN                             = " "0 (RET_PULSE_DIS),1 (RET_PULSE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RET_PULSE_WIDTH                          = " "0 (RET_PULSE_WIDTH_10US),1 (RET_PULSE_WIDTH_5US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RET_CP_CAP_SIZE                          = " "0 (X1),1 (X1P5),2 (X2P5),3 (X4P5)"
    tree.end
    tree "LDO02_CONFIG_CTL1"
      sgroup "LDO02_CONFIG_CTL1 (at 0x14152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LV_BUFFER_EN                             = " "0 (LV_BUFFER_DISABLED),1 (LV_BUFFER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AMP_BIAS_TURBO                           = " "0 (AMP_BIAS_TURBO_DIS),1 (AMP_BIAS_TURBO_EN)"
    tree.end
    tree "LDO02_BYPASS_CTL1"
      sgroup "LDO02_BYPASS_CTL1 (at 0x14153)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO02_BYPASS_CTL2"
      sgroup "LDO02_BYPASS_CTL2 (at 0x14154)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO02_STEPPER_CTL"
      sgroup "LDO02_STEPPER_CTL (at 0x14161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_DELAY                               = " "0 (DELAY_2_CLK),1 (DELAY_4_CLK),2 (DELAY_8_CLK),3 (DELAY_16_CLK)"
    tree.end
    tree "LDO02_OCP_CTL1"
      sgroup "LDO02_OCP_CTL1 (at 0x14166)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO02_ULS_VSET_LB"
      sgroup "LDO02_ULS_VSET_LB (at 0x14168)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO02_ULS_VSET_UB"
      sgroup "LDO02_ULS_VSET_UB (at 0x14169)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO02_STATUS_DEB_CTL"
      sgroup "LDO02_STATUS_DEB_CTL (at 0x14170)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO02_ECM_EN_CTL"
      sgroup "LDO02_ECM_EN_CTL (at 0x14180)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO02_ECM_CONFIG"
      sgroup "LDO02_ECM_CONFIG (at 0x14181)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO02_ECM_DATA_LB"
      sgroup "LDO02_ECM_DATA_LB (at 0x14184)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO02_ECM_DATA_UB"
      sgroup "LDO02_ECM_DATA_UB (at 0x14185)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO02_SEC_ACCESS"
      sgroup "LDO02_SEC_ACCESS (at 0x141d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO02_PERPH_RESET_CTL1"
      sgroup "LDO02_PERPH_RESET_CTL1 (at 0x141d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO02_PERPH_RESET_CTL2"
      sgroup "LDO02_PERPH_RESET_CTL2 (at 0x141d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO02_PERPH_RESET_CTL3"
      sgroup "LDO02_PERPH_RESET_CTL3 (at 0x141da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO02_PERPH_RESET_CTL4"
      sgroup "LDO02_PERPH_RESET_CTL4 (at 0x141db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO02_INT_TEST1"
      sgroup "LDO02_INT_TEST1 (at 0x141e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO02_INT_TEST_VAL"
      sgroup "LDO02_INT_TEST_VAL (at 0x141e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO02_TEST1"
      sgroup "LDO02_TEST1 (at 0x141e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO02_TEST2"
      sgroup "LDO02_TEST2 (at 0x141e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (STEPPER_DONE_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (D_D2A_LDO_VSET_DO_2_0),5 (D_A2D_RM_VREG_OK_DI_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (D_D2A_RET_MODE_EN_DO_D_A2D_RM_READY_DI_D_D2A_AMP_EN_DO),7 (D_A2D_RM_DISCHARGE_STS_DI_D_A2D_RM_CHARGE_STS_DI_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO02_TEST3"
      sgroup "LDO02_TEST3 (at 0x141e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_SELECT                                = " "0 (STEPPING_IN_SOFTSTART_EN),1 (STEPPING_IN_SOFTSTART_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO02_ECM_TEST1"
      sgroup "LDO02_ECM_TEST1 (at 0x141e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO02_ECM_TEST2"
      sgroup "LDO02_ECM_TEST2 (at 0x141e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO02_TRIM_NUM"
      sgroup "LDO02_TRIM_NUM (at 0x141f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO02_TRIM_CTRL"
      sgroup "LDO02_TRIM_CTRL (at 0x141f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
    tree "LDO02_RM_TRIM_CTRL"
      sgroup "LDO02_RM_TRIM_CTRL (at 0x141f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        set &access:&cmd_addr %l 0x8041f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x41f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RM_TRIM_CTRL                             = "
    tree.end
  tree.end
tree.end
tree "LDO03"
  tree "LDO03"
    tree "LDO03_REVISION1"
      sgroup "LDO03_REVISION1 (at 0x14200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO03_REVISION2"
      sgroup "LDO03_REVISION2 (at 0x14201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO03_REVISION3"
      sgroup "LDO03_REVISION3 (at 0x14202)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO03_REVISION4"
      sgroup "LDO03_REVISION4 (at 0x14203)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO03_PERPH_TYPE"
      sgroup "LDO03_PERPH_TYPE (at 0x14204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO03_PERPH_SUBTYPE"
      sgroup "LDO03_PERPH_SUBTYPE (at 0x14205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO03_STATUS1"
      sgroup "LDO03_STATUS1 (at 0x14208)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO03_STATUS3"
      sgroup "LDO03_STATUS3 (at 0x1420a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80420a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x420a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO03_STATUS4"
      sgroup "LDO03_STATUS4 (at 0x1420b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80420b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x420b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO03_INT_RT_STS"
      sgroup "LDO03_INT_RT_STS (at 0x14210)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO03_INT_SET_TYPE"
      sgroup "LDO03_INT_SET_TYPE (at 0x14211)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO03_INT_POLARITY_HIGH"
      sgroup "LDO03_INT_POLARITY_HIGH (at 0x14212)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO03_INT_POLARITY_LOW"
      sgroup "LDO03_INT_POLARITY_LOW (at 0x14213)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO03_INT_LATCHED_CLR"
      sgroup "LDO03_INT_LATCHED_CLR (at 0x14214)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO03_INT_EN_SET"
      sgroup "LDO03_INT_EN_SET (at 0x14215)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO03_INT_EN_CLR"
      sgroup "LDO03_INT_EN_CLR (at 0x14216)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO03_INT_LATCHED_STS"
      sgroup "LDO03_INT_LATCHED_STS (at 0x14218)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO03_INT_PENDING_STS"
      sgroup "LDO03_INT_PENDING_STS (at 0x14219)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO03_INT_MID_SEL"
      sgroup "LDO03_INT_MID_SEL (at 0x1421a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO03_INT_PRIORITY"
      sgroup "LDO03_INT_PRIORITY (at 0x1421b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80421b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x421b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO03_VSET_LB"
      sgroup "LDO03_VSET_LB (at 0x14240)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO03_VSET_UB"
      sgroup "LDO03_VSET_UB (at 0x14241)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO03_VSET_VALID_LB"
      sgroup "LDO03_VSET_VALID_LB (at 0x14242)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO03_VSET_VALID_UB"
      sgroup "LDO03_VSET_VALID_UB (at 0x14243)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO03_MODE_CTL1"
      sgroup "LDO03_MODE_CTL1 (at 0x14245)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO03_EN_CTL"
      sgroup "LDO03_EN_CTL (at 0x14246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO03_FOLLOW_HWEN"
      sgroup "LDO03_FOLLOW_HWEN (at 0x14247)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO03_PD_CTL"
      sgroup "LDO03_PD_CTL (at 0x14248)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO03_MODE_CTL2"
      sgroup "LDO03_MODE_CTL2 (at 0x14249)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO03_RETENTION_CTL1"
      sgroup "LDO03_RETENTION_CTL1 (at 0x1424a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x80424a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x424a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RET_HYST_HIGH                            = " "0 (VSET),1 (VSET_PLUS_2LSB),2 (VSET_PLUS_4LSB),3 (VSET_PLUS_6LSB)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RET_HYST_LOW                             = " "0 (VSET_ADD_0),1 (VSET_ADD_1),2 (VSET_ADD_2),3 (VSET_ADD_3)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RET_PULSE_EN                             = " "0 (RET_PULSE_DIS),1 (RET_PULSE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RET_PULSE_WIDTH                          = " "0 (RET_PULSE_WIDTH_10US),1 (RET_PULSE_WIDTH_5US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RET_CP_CAP_SIZE                          = " "0 (X1),1 (X1P5),2 (X2P5),3 (X4P5)"
    tree.end
    tree "LDO03_CONFIG_CTL1"
      sgroup "LDO03_CONFIG_CTL1 (at 0x14252)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LV_BUFFER_EN                             = " "0 (LV_BUFFER_DISABLED),1 (LV_BUFFER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AMP_BIAS_TURBO                           = " "0 (AMP_BIAS_TURBO_DIS),1 (AMP_BIAS_TURBO_EN)"
    tree.end
    tree "LDO03_BYPASS_CTL1"
      sgroup "LDO03_BYPASS_CTL1 (at 0x14253)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO03_BYPASS_CTL2"
      sgroup "LDO03_BYPASS_CTL2 (at 0x14254)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO03_STEPPER_CTL"
      sgroup "LDO03_STEPPER_CTL (at 0x14261)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_DELAY                               = " "0 (DELAY_2_CLK),1 (DELAY_4_CLK),2 (DELAY_8_CLK),3 (DELAY_16_CLK)"
    tree.end
    tree "LDO03_OCP_CTL1"
      sgroup "LDO03_OCP_CTL1 (at 0x14266)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO03_ULS_VSET_LB"
      sgroup "LDO03_ULS_VSET_LB (at 0x14268)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO03_ULS_VSET_UB"
      sgroup "LDO03_ULS_VSET_UB (at 0x14269)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO03_STATUS_DEB_CTL"
      sgroup "LDO03_STATUS_DEB_CTL (at 0x14270)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO03_ECM_EN_CTL"
      sgroup "LDO03_ECM_EN_CTL (at 0x14280)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO03_ECM_CONFIG"
      sgroup "LDO03_ECM_CONFIG (at 0x14281)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO03_ECM_DATA_LB"
      sgroup "LDO03_ECM_DATA_LB (at 0x14284)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO03_ECM_DATA_UB"
      sgroup "LDO03_ECM_DATA_UB (at 0x14285)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO03_SEC_ACCESS"
      sgroup "LDO03_SEC_ACCESS (at 0x142d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO03_PERPH_RESET_CTL1"
      sgroup "LDO03_PERPH_RESET_CTL1 (at 0x142d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO03_PERPH_RESET_CTL2"
      sgroup "LDO03_PERPH_RESET_CTL2 (at 0x142d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO03_PERPH_RESET_CTL3"
      sgroup "LDO03_PERPH_RESET_CTL3 (at 0x142da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO03_PERPH_RESET_CTL4"
      sgroup "LDO03_PERPH_RESET_CTL4 (at 0x142db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO03_INT_TEST1"
      sgroup "LDO03_INT_TEST1 (at 0x142e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO03_INT_TEST_VAL"
      sgroup "LDO03_INT_TEST_VAL (at 0x142e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO03_TEST1"
      sgroup "LDO03_TEST1 (at 0x142e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO03_TEST2"
      sgroup "LDO03_TEST2 (at 0x142e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (STEPPER_DONE_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (D_D2A_LDO_VSET_DO_2_0),5 (D_A2D_RM_VREG_OK_DI_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (D_D2A_RET_MODE_EN_DO_D_A2D_RM_READY_DI_D_D2A_AMP_EN_DO),7 (D_A2D_RM_DISCHARGE_STS_DI_D_A2D_RM_CHARGE_STS_DI_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO03_TEST3"
      sgroup "LDO03_TEST3 (at 0x142e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_SELECT                                = " "0 (STEPPING_IN_SOFTSTART_EN),1 (STEPPING_IN_SOFTSTART_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO03_ECM_TEST1"
      sgroup "LDO03_ECM_TEST1 (at 0x142e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO03_ECM_TEST2"
      sgroup "LDO03_ECM_TEST2 (at 0x142e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO03_TRIM_NUM"
      sgroup "LDO03_TRIM_NUM (at 0x142f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO03_TRIM_CTRL"
      sgroup "LDO03_TRIM_CTRL (at 0x142f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
    tree "LDO03_RM_TRIM_CTRL"
      sgroup "LDO03_RM_TRIM_CTRL (at 0x142f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        set &access:&cmd_addr %l 0x8042f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x42f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RM_TRIM_CTRL                             = "
    tree.end
  tree.end
tree.end
tree "LDO04"
  tree "LDO04"
    tree "LDO04_REVISION1"
      sgroup "LDO04_REVISION1 (at 0x14300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO04_REVISION2"
      sgroup "LDO04_REVISION2 (at 0x14301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO04_REVISION3"
      sgroup "LDO04_REVISION3 (at 0x14302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO04_REVISION4"
      sgroup "LDO04_REVISION4 (at 0x14303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO04_PERPH_TYPE"
      sgroup "LDO04_PERPH_TYPE (at 0x14304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO04_PERPH_SUBTYPE"
      sgroup "LDO04_PERPH_SUBTYPE (at 0x14305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO04_STATUS1"
      sgroup "LDO04_STATUS1 (at 0x14308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO04_STATUS3"
      sgroup "LDO04_STATUS3 (at 0x1430a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80430a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x430a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO04_STATUS4"
      sgroup "LDO04_STATUS4 (at 0x1430b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80430b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x430b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO04_INT_RT_STS"
      sgroup "LDO04_INT_RT_STS (at 0x14310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO04_INT_SET_TYPE"
      sgroup "LDO04_INT_SET_TYPE (at 0x14311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO04_INT_POLARITY_HIGH"
      sgroup "LDO04_INT_POLARITY_HIGH (at 0x14312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO04_INT_POLARITY_LOW"
      sgroup "LDO04_INT_POLARITY_LOW (at 0x14313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO04_INT_LATCHED_CLR"
      sgroup "LDO04_INT_LATCHED_CLR (at 0x14314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO04_INT_EN_SET"
      sgroup "LDO04_INT_EN_SET (at 0x14315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO04_INT_EN_CLR"
      sgroup "LDO04_INT_EN_CLR (at 0x14316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO04_INT_LATCHED_STS"
      sgroup "LDO04_INT_LATCHED_STS (at 0x14318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO04_INT_PENDING_STS"
      sgroup "LDO04_INT_PENDING_STS (at 0x14319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO04_INT_MID_SEL"
      sgroup "LDO04_INT_MID_SEL (at 0x1431a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO04_INT_PRIORITY"
      sgroup "LDO04_INT_PRIORITY (at 0x1431b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80431b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x431b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO04_VSET_LB"
      sgroup "LDO04_VSET_LB (at 0x14340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO04_VSET_UB"
      sgroup "LDO04_VSET_UB (at 0x14341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO04_VSET_VALID_LB"
      sgroup "LDO04_VSET_VALID_LB (at 0x14342)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO04_VSET_VALID_UB"
      sgroup "LDO04_VSET_VALID_UB (at 0x14343)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO04_MODE_CTL1"
      sgroup "LDO04_MODE_CTL1 (at 0x14345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO04_EN_CTL"
      sgroup "LDO04_EN_CTL (at 0x14346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO04_FOLLOW_HWEN"
      sgroup "LDO04_FOLLOW_HWEN (at 0x14347)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO04_PD_CTL"
      sgroup "LDO04_PD_CTL (at 0x14348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO04_MODE_CTL2"
      sgroup "LDO04_MODE_CTL2 (at 0x14349)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO04_RETENTION_CTL1"
      sgroup "LDO04_RETENTION_CTL1 (at 0x1434a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x80434a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x434a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RET_HYST_HIGH                            = " "0 (VSET),1 (VSET_PLUS_2LSB),2 (VSET_PLUS_4LSB),3 (VSET_PLUS_6LSB)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RET_HYST_LOW                             = " "0 (VSET_ADD_0),1 (VSET_ADD_1),2 (VSET_ADD_2),3 (VSET_ADD_3)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RET_PULSE_EN                             = " "0 (RET_PULSE_DIS),1 (RET_PULSE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RET_PULSE_WIDTH                          = " "0 (RET_PULSE_WIDTH_10US),1 (RET_PULSE_WIDTH_5US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RET_CP_CAP_SIZE                          = " "0 (X1),1 (X1P5),2 (X2P5),3 (X4P5)"
    tree.end
    tree "LDO04_CONFIG_CTL1"
      sgroup "LDO04_CONFIG_CTL1 (at 0x14352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LV_BUFFER_EN                             = " "0 (LV_BUFFER_DISABLED),1 (LV_BUFFER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AMP_BIAS_TURBO                           = " "0 (AMP_BIAS_TURBO_DIS),1 (AMP_BIAS_TURBO_EN)"
    tree.end
    tree "LDO04_BYPASS_CTL1"
      sgroup "LDO04_BYPASS_CTL1 (at 0x14353)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO04_BYPASS_CTL2"
      sgroup "LDO04_BYPASS_CTL2 (at 0x14354)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO04_STEPPER_CTL"
      sgroup "LDO04_STEPPER_CTL (at 0x14361)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_DELAY                               = " "0 (DELAY_2_CLK),1 (DELAY_4_CLK),2 (DELAY_8_CLK),3 (DELAY_16_CLK)"
    tree.end
    tree "LDO04_OCP_CTL1"
      sgroup "LDO04_OCP_CTL1 (at 0x14366)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO04_ULS_VSET_LB"
      sgroup "LDO04_ULS_VSET_LB (at 0x14368)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO04_ULS_VSET_UB"
      sgroup "LDO04_ULS_VSET_UB (at 0x14369)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO04_STATUS_DEB_CTL"
      sgroup "LDO04_STATUS_DEB_CTL (at 0x14370)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO04_ECM_EN_CTL"
      sgroup "LDO04_ECM_EN_CTL (at 0x14380)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO04_ECM_CONFIG"
      sgroup "LDO04_ECM_CONFIG (at 0x14381)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO04_ECM_DATA_LB"
      sgroup "LDO04_ECM_DATA_LB (at 0x14384)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO04_ECM_DATA_UB"
      sgroup "LDO04_ECM_DATA_UB (at 0x14385)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO04_SEC_ACCESS"
      sgroup "LDO04_SEC_ACCESS (at 0x143d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO04_PERPH_RESET_CTL1"
      sgroup "LDO04_PERPH_RESET_CTL1 (at 0x143d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO04_PERPH_RESET_CTL2"
      sgroup "LDO04_PERPH_RESET_CTL2 (at 0x143d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO04_PERPH_RESET_CTL3"
      sgroup "LDO04_PERPH_RESET_CTL3 (at 0x143da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO04_PERPH_RESET_CTL4"
      sgroup "LDO04_PERPH_RESET_CTL4 (at 0x143db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO04_INT_TEST1"
      sgroup "LDO04_INT_TEST1 (at 0x143e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO04_INT_TEST_VAL"
      sgroup "LDO04_INT_TEST_VAL (at 0x143e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO04_TEST1"
      sgroup "LDO04_TEST1 (at 0x143e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO04_TEST2"
      sgroup "LDO04_TEST2 (at 0x143e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (STEPPER_DONE_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (D_D2A_LDO_VSET_DO_2_0),5 (D_A2D_RM_VREG_OK_DI_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (D_D2A_RET_MODE_EN_DO_D_A2D_RM_READY_DI_D_D2A_AMP_EN_DO),7 (D_A2D_RM_DISCHARGE_STS_DI_D_A2D_RM_CHARGE_STS_DI_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO04_TEST3"
      sgroup "LDO04_TEST3 (at 0x143e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_SELECT                                = " "0 (STEPPING_IN_SOFTSTART_EN),1 (STEPPING_IN_SOFTSTART_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO04_ECM_TEST1"
      sgroup "LDO04_ECM_TEST1 (at 0x143e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO04_ECM_TEST2"
      sgroup "LDO04_ECM_TEST2 (at 0x143e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO04_TRIM_NUM"
      sgroup "LDO04_TRIM_NUM (at 0x143f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO04_TRIM_CTRL"
      sgroup "LDO04_TRIM_CTRL (at 0x143f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
    tree "LDO04_RM_TRIM_CTRL"
      sgroup "LDO04_RM_TRIM_CTRL (at 0x143f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        set &access:&cmd_addr %l 0x8043f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x43f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RM_TRIM_CTRL                             = "
    tree.end
  tree.end
tree.end
tree "LDO05"
  tree "LDO05"
    tree "LDO05_REVISION1"
      sgroup "LDO05_REVISION1 (at 0x14400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO05_REVISION2"
      sgroup "LDO05_REVISION2 (at 0x14401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO05_REVISION3"
      sgroup "LDO05_REVISION3 (at 0x14402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO05_REVISION4"
      sgroup "LDO05_REVISION4 (at 0x14403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO05_PERPH_TYPE"
      sgroup "LDO05_PERPH_TYPE (at 0x14404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO05_PERPH_SUBTYPE"
      sgroup "LDO05_PERPH_SUBTYPE (at 0x14405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO05_STATUS1"
      sgroup "LDO05_STATUS1 (at 0x14408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO05_STATUS3"
      sgroup "LDO05_STATUS3 (at 0x1440a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80440a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x440a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO05_STATUS4"
      sgroup "LDO05_STATUS4 (at 0x1440b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80440b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x440b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO05_INT_RT_STS"
      sgroup "LDO05_INT_RT_STS (at 0x14410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO05_INT_SET_TYPE"
      sgroup "LDO05_INT_SET_TYPE (at 0x14411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO05_INT_POLARITY_HIGH"
      sgroup "LDO05_INT_POLARITY_HIGH (at 0x14412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO05_INT_POLARITY_LOW"
      sgroup "LDO05_INT_POLARITY_LOW (at 0x14413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO05_INT_LATCHED_CLR"
      sgroup "LDO05_INT_LATCHED_CLR (at 0x14414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO05_INT_EN_SET"
      sgroup "LDO05_INT_EN_SET (at 0x14415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO05_INT_EN_CLR"
      sgroup "LDO05_INT_EN_CLR (at 0x14416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO05_INT_LATCHED_STS"
      sgroup "LDO05_INT_LATCHED_STS (at 0x14418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO05_INT_PENDING_STS"
      sgroup "LDO05_INT_PENDING_STS (at 0x14419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO05_INT_MID_SEL"
      sgroup "LDO05_INT_MID_SEL (at 0x1441a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO05_INT_PRIORITY"
      sgroup "LDO05_INT_PRIORITY (at 0x1441b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x80441b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x441b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO05_VSET_LB"
      sgroup "LDO05_VSET_LB (at 0x14440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO05_VSET_UB"
      sgroup "LDO05_VSET_UB (at 0x14441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO05_VSET_VALID_LB"
      sgroup "LDO05_VSET_VALID_LB (at 0x14442)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO05_VSET_VALID_UB"
      sgroup "LDO05_VSET_VALID_UB (at 0x14443)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO05_MODE_CTL1"
      sgroup "LDO05_MODE_CTL1 (at 0x14445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO05_EN_CTL"
      sgroup "LDO05_EN_CTL (at 0x14446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO05_FOLLOW_HWEN"
      sgroup "LDO05_FOLLOW_HWEN (at 0x14447)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO05_PD_CTL"
      sgroup "LDO05_PD_CTL (at 0x14448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO05_MODE_CTL2"
      sgroup "LDO05_MODE_CTL2 (at 0x14449)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO05_CONFIG_CTL1"
      sgroup "LDO05_CONFIG_CTL1 (at 0x14452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GATE_PULL_UP_EN                          = " "0 (GATE_PU_DIABLED),1 (GATE_PU_ENABLED)"
    tree.end
    tree "LDO05_BYPASS_CTL1"
      sgroup "LDO05_BYPASS_CTL1 (at 0x14453)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO05_BYPASS_CTL2"
      sgroup "LDO05_BYPASS_CTL2 (at 0x14454)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO05_OCP_CTL1"
      sgroup "LDO05_OCP_CTL1 (at 0x14466)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO05_ULS_VSET_LB"
      sgroup "LDO05_ULS_VSET_LB (at 0x14468)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO05_ULS_VSET_UB"
      sgroup "LDO05_ULS_VSET_UB (at 0x14469)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO05_STATUS_DEB_CTL"
      sgroup "LDO05_STATUS_DEB_CTL (at 0x14470)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO05_ECM_EN_CTL"
      sgroup "LDO05_ECM_EN_CTL (at 0x14480)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO05_ECM_CONFIG"
      sgroup "LDO05_ECM_CONFIG (at 0x14481)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO05_ECM_DATA_LB"
      sgroup "LDO05_ECM_DATA_LB (at 0x14484)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO05_ECM_DATA_UB"
      sgroup "LDO05_ECM_DATA_UB (at 0x14485)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO05_SEC_ACCESS"
      sgroup "LDO05_SEC_ACCESS (at 0x144d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO05_PERPH_RESET_CTL1"
      sgroup "LDO05_PERPH_RESET_CTL1 (at 0x144d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO05_PERPH_RESET_CTL2"
      sgroup "LDO05_PERPH_RESET_CTL2 (at 0x144d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO05_PERPH_RESET_CTL3"
      sgroup "LDO05_PERPH_RESET_CTL3 (at 0x144da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO05_PERPH_RESET_CTL4"
      sgroup "LDO05_PERPH_RESET_CTL4 (at 0x144db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO05_INT_TEST1"
      sgroup "LDO05_INT_TEST1 (at 0x144e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO05_INT_TEST_VAL"
      sgroup "LDO05_INT_TEST_VAL (at 0x144e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO05_TEST1"
      sgroup "LDO05_TEST1 (at 0x144e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO05_TEST2"
      sgroup "LDO05_TEST2 (at 0x144e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (GROUND_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (GROUND_D_D2A_BYPASS_EN_DO_D_A2D_VOUTOK_DI),5 (GROUND_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (DIG_ASSIST_AUTOBYP_EXIT_DIG_ASSIST_AUTOBYP_ENTER_D_D2A_AMP_EN_DO),7 (GROUND_GROUND_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO05_TEST3"
      sgroup "LDO05_TEST3 (at 0x144e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AB_PULL_DOWN_EN                          = " "0 (AB_PD_DISABLED),1 (AB_PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_VREF_BUF_EN                           = " "0 (SOFTSTART_VREF_BUF_DIS),1 (SOFTSTART_VREF_BUF_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO05_ECM_TEST1"
      sgroup "LDO05_ECM_TEST1 (at 0x144e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO05_ECM_TEST2"
      sgroup "LDO05_ECM_TEST2 (at 0x144e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO05_TRIM_NUM"
      sgroup "LDO05_TRIM_NUM (at 0x144f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO05_TRIM_CTRL"
      sgroup "LDO05_TRIM_CTRL (at 0x144f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        set &access:&cmd_addr %l 0x8044f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x44f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO06"
  tree "LDO06"
    tree "LDO06_REVISION1"
      sgroup "LDO06_REVISION1 (at 0x14500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO06_REVISION2"
      sgroup "LDO06_REVISION2 (at 0x14501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO06_REVISION3"
      sgroup "LDO06_REVISION3 (at 0x14502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO06_REVISION4"
      sgroup "LDO06_REVISION4 (at 0x14503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO06_PERPH_TYPE"
      sgroup "LDO06_PERPH_TYPE (at 0x14504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO06_PERPH_SUBTYPE"
      sgroup "LDO06_PERPH_SUBTYPE (at 0x14505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO06_STATUS1"
      sgroup "LDO06_STATUS1 (at 0x14508)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO06_STATUS3"
      sgroup "LDO06_STATUS3 (at 0x1450a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80450a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x450a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO06_STATUS4"
      sgroup "LDO06_STATUS4 (at 0x1450b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80450b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x450b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO06_INT_RT_STS"
      sgroup "LDO06_INT_RT_STS (at 0x14510)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO06_INT_SET_TYPE"
      sgroup "LDO06_INT_SET_TYPE (at 0x14511)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO06_INT_POLARITY_HIGH"
      sgroup "LDO06_INT_POLARITY_HIGH (at 0x14512)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO06_INT_POLARITY_LOW"
      sgroup "LDO06_INT_POLARITY_LOW (at 0x14513)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO06_INT_LATCHED_CLR"
      sgroup "LDO06_INT_LATCHED_CLR (at 0x14514)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO06_INT_EN_SET"
      sgroup "LDO06_INT_EN_SET (at 0x14515)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO06_INT_EN_CLR"
      sgroup "LDO06_INT_EN_CLR (at 0x14516)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO06_INT_LATCHED_STS"
      sgroup "LDO06_INT_LATCHED_STS (at 0x14518)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO06_INT_PENDING_STS"
      sgroup "LDO06_INT_PENDING_STS (at 0x14519)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO06_INT_MID_SEL"
      sgroup "LDO06_INT_MID_SEL (at 0x1451a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO06_INT_PRIORITY"
      sgroup "LDO06_INT_PRIORITY (at 0x1451b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x80451b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x451b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO06_VSET_LB"
      sgroup "LDO06_VSET_LB (at 0x14540)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO06_VSET_UB"
      sgroup "LDO06_VSET_UB (at 0x14541)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO06_VSET_VALID_LB"
      sgroup "LDO06_VSET_VALID_LB (at 0x14542)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO06_VSET_VALID_UB"
      sgroup "LDO06_VSET_VALID_UB (at 0x14543)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO06_MODE_CTL1"
      sgroup "LDO06_MODE_CTL1 (at 0x14545)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO06_EN_CTL"
      sgroup "LDO06_EN_CTL (at 0x14546)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO06_FOLLOW_HWEN"
      sgroup "LDO06_FOLLOW_HWEN (at 0x14547)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO06_PD_CTL"
      sgroup "LDO06_PD_CTL (at 0x14548)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO06_MODE_CTL2"
      sgroup "LDO06_MODE_CTL2 (at 0x14549)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO06_CONFIG_CTL1"
      sgroup "LDO06_CONFIG_CTL1 (at 0x14552)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GATE_PULL_UP_EN                          = " "0 (GATE_PU_DIABLED),1 (GATE_PU_ENABLED)"
    tree.end
    tree "LDO06_BYPASS_CTL1"
      sgroup "LDO06_BYPASS_CTL1 (at 0x14553)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO06_BYPASS_CTL2"
      sgroup "LDO06_BYPASS_CTL2 (at 0x14554)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO06_OCP_CTL1"
      sgroup "LDO06_OCP_CTL1 (at 0x14566)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO06_ULS_VSET_LB"
      sgroup "LDO06_ULS_VSET_LB (at 0x14568)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO06_ULS_VSET_UB"
      sgroup "LDO06_ULS_VSET_UB (at 0x14569)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO06_STATUS_DEB_CTL"
      sgroup "LDO06_STATUS_DEB_CTL (at 0x14570)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO06_ECM_EN_CTL"
      sgroup "LDO06_ECM_EN_CTL (at 0x14580)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO06_ECM_CONFIG"
      sgroup "LDO06_ECM_CONFIG (at 0x14581)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO06_ECM_DATA_LB"
      sgroup "LDO06_ECM_DATA_LB (at 0x14584)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO06_ECM_DATA_UB"
      sgroup "LDO06_ECM_DATA_UB (at 0x14585)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO06_SEC_ACCESS"
      sgroup "LDO06_SEC_ACCESS (at 0x145d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO06_PERPH_RESET_CTL1"
      sgroup "LDO06_PERPH_RESET_CTL1 (at 0x145d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO06_PERPH_RESET_CTL2"
      sgroup "LDO06_PERPH_RESET_CTL2 (at 0x145d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO06_PERPH_RESET_CTL3"
      sgroup "LDO06_PERPH_RESET_CTL3 (at 0x145da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO06_PERPH_RESET_CTL4"
      sgroup "LDO06_PERPH_RESET_CTL4 (at 0x145db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO06_INT_TEST1"
      sgroup "LDO06_INT_TEST1 (at 0x145e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO06_INT_TEST_VAL"
      sgroup "LDO06_INT_TEST_VAL (at 0x145e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO06_TEST1"
      sgroup "LDO06_TEST1 (at 0x145e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO06_TEST2"
      sgroup "LDO06_TEST2 (at 0x145e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (GROUND_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (GROUND_D_D2A_BYPASS_EN_DO_D_A2D_VOUTOK_DI),5 (GROUND_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (DIG_ASSIST_AUTOBYP_EXIT_DIG_ASSIST_AUTOBYP_ENTER_D_D2A_AMP_EN_DO),7 (GROUND_GROUND_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO06_TEST3"
      sgroup "LDO06_TEST3 (at 0x145e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AB_PULL_DOWN_EN                          = " "0 (AB_PD_DISABLED),1 (AB_PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_VREF_BUF_EN                           = " "0 (SOFTSTART_VREF_BUF_DIS),1 (SOFTSTART_VREF_BUF_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO06_ECM_TEST1"
      sgroup "LDO06_ECM_TEST1 (at 0x145e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO06_ECM_TEST2"
      sgroup "LDO06_ECM_TEST2 (at 0x145e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO06_TRIM_NUM"
      sgroup "LDO06_TRIM_NUM (at 0x145f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO06_TRIM_CTRL"
      sgroup "LDO06_TRIM_CTRL (at 0x145f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        set &access:&cmd_addr %l 0x8045f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x45f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO07"
  tree "LDO07"
    tree "LDO07_REVISION1"
      sgroup "LDO07_REVISION1 (at 0x14600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO07_REVISION2"
      sgroup "LDO07_REVISION2 (at 0x14601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO07_REVISION3"
      sgroup "LDO07_REVISION3 (at 0x14602)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO07_REVISION4"
      sgroup "LDO07_REVISION4 (at 0x14603)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO07_PERPH_TYPE"
      sgroup "LDO07_PERPH_TYPE (at 0x14604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO07_PERPH_SUBTYPE"
      sgroup "LDO07_PERPH_SUBTYPE (at 0x14605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO07_STATUS1"
      sgroup "LDO07_STATUS1 (at 0x14608)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO07_STATUS3"
      sgroup "LDO07_STATUS3 (at 0x1460a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80460a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x460a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO07_STATUS4"
      sgroup "LDO07_STATUS4 (at 0x1460b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80460b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x460b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
    tree.end
    tree "LDO07_INT_RT_STS"
      sgroup "LDO07_INT_RT_STS (at 0x14610)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO07_INT_SET_TYPE"
      sgroup "LDO07_INT_SET_TYPE (at 0x14611)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO07_INT_POLARITY_HIGH"
      sgroup "LDO07_INT_POLARITY_HIGH (at 0x14612)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO07_INT_POLARITY_LOW"
      sgroup "LDO07_INT_POLARITY_LOW (at 0x14613)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO07_INT_LATCHED_CLR"
      sgroup "LDO07_INT_LATCHED_CLR (at 0x14614)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO07_INT_EN_SET"
      sgroup "LDO07_INT_EN_SET (at 0x14615)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO07_INT_EN_CLR"
      sgroup "LDO07_INT_EN_CLR (at 0x14616)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO07_INT_LATCHED_STS"
      sgroup "LDO07_INT_LATCHED_STS (at 0x14618)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO07_INT_PENDING_STS"
      sgroup "LDO07_INT_PENDING_STS (at 0x14619)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO07_INT_MID_SEL"
      sgroup "LDO07_INT_MID_SEL (at 0x1461a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80461a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x461a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO07_INT_PRIORITY"
      sgroup "LDO07_INT_PRIORITY (at 0x1461b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x80461b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x461b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO07_VSET_LB"
      sgroup "LDO07_VSET_LB (at 0x14640)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO07_VSET_UB"
      sgroup "LDO07_VSET_UB (at 0x14641)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO07_VSET_VALID_LB"
      sgroup "LDO07_VSET_VALID_LB (at 0x14642)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO07_VSET_VALID_UB"
      sgroup "LDO07_VSET_VALID_UB (at 0x14643)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO07_MODE_CTL1"
      sgroup "LDO07_MODE_CTL1 (at 0x14645)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO07_EN_CTL"
      sgroup "LDO07_EN_CTL (at 0x14646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO07_FOLLOW_HWEN"
      sgroup "LDO07_FOLLOW_HWEN (at 0x14647)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO07_PD_CTL"
      sgroup "LDO07_PD_CTL (at 0x14648)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO07_MODE_CTL2"
      sgroup "LDO07_MODE_CTL2 (at 0x14649)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO07_BYPASS_CTL1"
      sgroup "LDO07_BYPASS_CTL1 (at 0x14653)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO07_OCP_CTL1"
      sgroup "LDO07_OCP_CTL1 (at 0x14666)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO07_ULS_VSET_LB"
      sgroup "LDO07_ULS_VSET_LB (at 0x14668)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO07_ULS_VSET_UB"
      sgroup "LDO07_ULS_VSET_UB (at 0x14669)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO07_STATUS_DEB_CTL"
      sgroup "LDO07_STATUS_DEB_CTL (at 0x14670)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO07_SEC_ACCESS"
      sgroup "LDO07_SEC_ACCESS (at 0x146d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO07_PERPH_RESET_CTL1"
      sgroup "LDO07_PERPH_RESET_CTL1 (at 0x146d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO07_PERPH_RESET_CTL2"
      sgroup "LDO07_PERPH_RESET_CTL2 (at 0x146d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO07_PERPH_RESET_CTL3"
      sgroup "LDO07_PERPH_RESET_CTL3 (at 0x146da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO07_PERPH_RESET_CTL4"
      sgroup "LDO07_PERPH_RESET_CTL4 (at 0x146db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO07_INT_TEST1"
      sgroup "LDO07_INT_TEST1 (at 0x146e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO07_INT_TEST_VAL"
      sgroup "LDO07_INT_TEST_VAL (at 0x146e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO07_TEST1"
      sgroup "LDO07_TEST1 (at 0x146e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO07_TEST2"
      sgroup "LDO07_TEST2 (at 0x146e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (GROUND_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_SOFTSTART_DONE_D_A2D_VREG_OK_DI),4 (GROUND_D_D2A_BYPASS_EN_DO_D_A2D_VOUTOK_DI),5 (GROUND_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (GROUND_GROUND_D_D2A_AMP_EN_DO),7 (GROUND_GROUND_GROUND)"
    tree.end
    tree "LDO07_TEST3"
      sgroup "LDO07_TEST3 (at 0x146e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AB_PULL_DOWN_EN                          = " "0 (AB_PD_DISABLED),1 (AB_PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_VREF_BUF_EN                           = " "0 (SOFTSTART_VREF_BUF_DIS),1 (SOFTSTART_VREF_BUF_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO07_TRIM_NUM"
      sgroup "LDO07_TRIM_NUM (at 0x146f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO07_TRIM_CTRL"
      sgroup "LDO07_TRIM_CTRL (at 0x146f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        set &access:&cmd_addr %l 0x8046f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x46f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO08"
  tree "LDO08"
    tree "LDO08_REVISION1"
      sgroup "LDO08_REVISION1 (at 0x14700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO08_REVISION2"
      sgroup "LDO08_REVISION2 (at 0x14701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO08_REVISION3"
      sgroup "LDO08_REVISION3 (at 0x14702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO08_REVISION4"
      sgroup "LDO08_REVISION4 (at 0x14703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO08_PERPH_TYPE"
      sgroup "LDO08_PERPH_TYPE (at 0x14704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO08_PERPH_SUBTYPE"
      sgroup "LDO08_PERPH_SUBTYPE (at 0x14705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO08_STATUS1"
      sgroup "LDO08_STATUS1 (at 0x14708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO08_STATUS3"
      sgroup "LDO08_STATUS3 (at 0x1470a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80470a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x470a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO08_STATUS4"
      sgroup "LDO08_STATUS4 (at 0x1470b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80470b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x470b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO08_INT_RT_STS"
      sgroup "LDO08_INT_RT_STS (at 0x14710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO08_INT_SET_TYPE"
      sgroup "LDO08_INT_SET_TYPE (at 0x14711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO08_INT_POLARITY_HIGH"
      sgroup "LDO08_INT_POLARITY_HIGH (at 0x14712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO08_INT_POLARITY_LOW"
      sgroup "LDO08_INT_POLARITY_LOW (at 0x14713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO08_INT_LATCHED_CLR"
      sgroup "LDO08_INT_LATCHED_CLR (at 0x14714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO08_INT_EN_SET"
      sgroup "LDO08_INT_EN_SET (at 0x14715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO08_INT_EN_CLR"
      sgroup "LDO08_INT_EN_CLR (at 0x14716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO08_INT_LATCHED_STS"
      sgroup "LDO08_INT_LATCHED_STS (at 0x14718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO08_INT_PENDING_STS"
      sgroup "LDO08_INT_PENDING_STS (at 0x14719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO08_INT_MID_SEL"
      sgroup "LDO08_INT_MID_SEL (at 0x1471a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80471a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x471a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO08_INT_PRIORITY"
      sgroup "LDO08_INT_PRIORITY (at 0x1471b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80471b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x471b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO08_VSET_LB"
      sgroup "LDO08_VSET_LB (at 0x14740)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO08_VSET_UB"
      sgroup "LDO08_VSET_UB (at 0x14741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO08_VSET_VALID_LB"
      sgroup "LDO08_VSET_VALID_LB (at 0x14742)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO08_VSET_VALID_UB"
      sgroup "LDO08_VSET_VALID_UB (at 0x14743)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO08_MODE_CTL1"
      sgroup "LDO08_MODE_CTL1 (at 0x14745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO08_EN_CTL"
      sgroup "LDO08_EN_CTL (at 0x14746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO08_FOLLOW_HWEN"
      sgroup "LDO08_FOLLOW_HWEN (at 0x14747)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO08_PD_CTL"
      sgroup "LDO08_PD_CTL (at 0x14748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO08_MODE_CTL2"
      sgroup "LDO08_MODE_CTL2 (at 0x14749)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO08_RETENTION_CTL1"
      sgroup "LDO08_RETENTION_CTL1 (at 0x1474a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x80474a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x474a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RET_HYST_HIGH                            = " "0 (VSET),1 (VSET_PLUS_2LSB),2 (VSET_PLUS_4LSB),3 (VSET_PLUS_6LSB)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RET_HYST_LOW                             = " "0 (VSET_ADD_0),1 (VSET_ADD_1),2 (VSET_ADD_2),3 (VSET_ADD_3)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RET_PULSE_EN                             = " "0 (RET_PULSE_DIS),1 (RET_PULSE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RET_PULSE_WIDTH                          = " "0 (RET_PULSE_WIDTH_10US),1 (RET_PULSE_WIDTH_5US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RET_CP_CAP_SIZE                          = " "0 (X1),1 (X1P5),2 (X2P5),3 (X4P5)"
    tree.end
    tree "LDO08_CONFIG_CTL1"
      sgroup "LDO08_CONFIG_CTL1 (at 0x14752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LV_BUFFER_EN                             = " "0 (LV_BUFFER_DISABLED),1 (LV_BUFFER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AMP_BIAS_TURBO                           = " "0 (AMP_BIAS_TURBO_DIS),1 (AMP_BIAS_TURBO_EN)"
    tree.end
    tree "LDO08_BYPASS_CTL1"
      sgroup "LDO08_BYPASS_CTL1 (at 0x14753)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO08_BYPASS_CTL2"
      sgroup "LDO08_BYPASS_CTL2 (at 0x14754)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO08_STEPPER_CTL"
      sgroup "LDO08_STEPPER_CTL (at 0x14761)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_DELAY                               = " "0 (DELAY_2_CLK),1 (DELAY_4_CLK),2 (DELAY_8_CLK),3 (DELAY_16_CLK)"
    tree.end
    tree "LDO08_OCP_CTL1"
      sgroup "LDO08_OCP_CTL1 (at 0x14766)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO08_ULS_VSET_LB"
      sgroup "LDO08_ULS_VSET_LB (at 0x14768)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO08_ULS_VSET_UB"
      sgroup "LDO08_ULS_VSET_UB (at 0x14769)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO08_STATUS_DEB_CTL"
      sgroup "LDO08_STATUS_DEB_CTL (at 0x14770)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO08_ECM_EN_CTL"
      sgroup "LDO08_ECM_EN_CTL (at 0x14780)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO08_ECM_CONFIG"
      sgroup "LDO08_ECM_CONFIG (at 0x14781)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO08_ECM_DATA_LB"
      sgroup "LDO08_ECM_DATA_LB (at 0x14784)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO08_ECM_DATA_UB"
      sgroup "LDO08_ECM_DATA_UB (at 0x14785)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO08_SEC_ACCESS"
      sgroup "LDO08_SEC_ACCESS (at 0x147d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO08_PERPH_RESET_CTL1"
      sgroup "LDO08_PERPH_RESET_CTL1 (at 0x147d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO08_PERPH_RESET_CTL2"
      sgroup "LDO08_PERPH_RESET_CTL2 (at 0x147d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO08_PERPH_RESET_CTL3"
      sgroup "LDO08_PERPH_RESET_CTL3 (at 0x147da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO08_PERPH_RESET_CTL4"
      sgroup "LDO08_PERPH_RESET_CTL4 (at 0x147db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO08_INT_TEST1"
      sgroup "LDO08_INT_TEST1 (at 0x147e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO08_INT_TEST_VAL"
      sgroup "LDO08_INT_TEST_VAL (at 0x147e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO08_TEST1"
      sgroup "LDO08_TEST1 (at 0x147e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO08_TEST2"
      sgroup "LDO08_TEST2 (at 0x147e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (STEPPER_DONE_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (D_D2A_LDO_VSET_DO_2_0),5 (D_A2D_RM_VREG_OK_DI_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (D_D2A_RET_MODE_EN_DO_D_A2D_RM_READY_DI_D_D2A_AMP_EN_DO),7 (D_A2D_RM_DISCHARGE_STS_DI_D_A2D_RM_CHARGE_STS_DI_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO08_TEST3"
      sgroup "LDO08_TEST3 (at 0x147e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_SELECT                                = " "0 (STEPPING_IN_SOFTSTART_EN),1 (STEPPING_IN_SOFTSTART_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO08_ECM_TEST1"
      sgroup "LDO08_ECM_TEST1 (at 0x147e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO08_ECM_TEST2"
      sgroup "LDO08_ECM_TEST2 (at 0x147e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO08_TRIM_NUM"
      sgroup "LDO08_TRIM_NUM (at 0x147f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO08_TRIM_CTRL"
      sgroup "LDO08_TRIM_CTRL (at 0x147f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
    tree "LDO08_RM_TRIM_CTRL"
      sgroup "LDO08_RM_TRIM_CTRL (at 0x147f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        set &access:&cmd_addr %l 0x8047f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x47f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RM_TRIM_CTRL                             = "
    tree.end
  tree.end
tree.end
tree "LDO09"
  tree "LDO09"
    tree "LDO09_REVISION1"
      sgroup "LDO09_REVISION1 (at 0x14800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO09_REVISION2"
      sgroup "LDO09_REVISION2 (at 0x14801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO09_REVISION3"
      sgroup "LDO09_REVISION3 (at 0x14802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO09_REVISION4"
      sgroup "LDO09_REVISION4 (at 0x14803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO09_PERPH_TYPE"
      sgroup "LDO09_PERPH_TYPE (at 0x14804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO09_PERPH_SUBTYPE"
      sgroup "LDO09_PERPH_SUBTYPE (at 0x14805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO09_STATUS1"
      sgroup "LDO09_STATUS1 (at 0x14808)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIG_ASSISTED_BYPASS_DETECTED             = " "0 (DIG_ASSISTED_BYPASS_NOT_DETECTED),1 (DIG_ASSISTED_BYPASS_DETECTED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO09_STATUS3"
      sgroup "LDO09_STATUS3 (at 0x1480a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80480a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x480a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO09_STATUS4"
      sgroup "LDO09_STATUS4 (at 0x1480b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80480b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x480b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "LDO09_INT_RT_STS"
      sgroup "LDO09_INT_RT_STS (at 0x14810)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO09_INT_SET_TYPE"
      sgroup "LDO09_INT_SET_TYPE (at 0x14811)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO09_INT_POLARITY_HIGH"
      sgroup "LDO09_INT_POLARITY_HIGH (at 0x14812)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO09_INT_POLARITY_LOW"
      sgroup "LDO09_INT_POLARITY_LOW (at 0x14813)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO09_INT_LATCHED_CLR"
      sgroup "LDO09_INT_LATCHED_CLR (at 0x14814)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO09_INT_EN_SET"
      sgroup "LDO09_INT_EN_SET (at 0x14815)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO09_INT_EN_CLR"
      sgroup "LDO09_INT_EN_CLR (at 0x14816)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO09_INT_LATCHED_STS"
      sgroup "LDO09_INT_LATCHED_STS (at 0x14818)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO09_INT_PENDING_STS"
      sgroup "LDO09_INT_PENDING_STS (at 0x14819)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO09_INT_MID_SEL"
      sgroup "LDO09_INT_MID_SEL (at 0x1481a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80481a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x481a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO09_INT_PRIORITY"
      sgroup "LDO09_INT_PRIORITY (at 0x1481b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80481b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x481b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO09_VSET_LB"
      sgroup "LDO09_VSET_LB (at 0x14840)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO09_VSET_UB"
      sgroup "LDO09_VSET_UB (at 0x14841)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO09_VSET_VALID_LB"
      sgroup "LDO09_VSET_VALID_LB (at 0x14842)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO09_VSET_VALID_UB"
      sgroup "LDO09_VSET_VALID_UB (at 0x14843)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO09_MODE_CTL1"
      sgroup "LDO09_MODE_CTL1 (at 0x14845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO09_EN_CTL"
      sgroup "LDO09_EN_CTL (at 0x14846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO09_FOLLOW_HWEN"
      sgroup "LDO09_FOLLOW_HWEN (at 0x14847)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO09_PD_CTL"
      sgroup "LDO09_PD_CTL (at 0x14848)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO09_MODE_CTL2"
      sgroup "LDO09_MODE_CTL2 (at 0x14849)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO09_RETENTION_CTL1"
      sgroup "LDO09_RETENTION_CTL1 (at 0x1484a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x80484a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x484a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   RET_HYST_HIGH                            = " "0 (VSET),1 (VSET_PLUS_2LSB),2 (VSET_PLUS_4LSB),3 (VSET_PLUS_6LSB)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RET_HYST_LOW                             = " "0 (VSET_ADD_0),1 (VSET_ADD_1),2 (VSET_ADD_2),3 (VSET_ADD_3)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RET_PULSE_EN                             = " "0 (RET_PULSE_DIS),1 (RET_PULSE_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RET_PULSE_WIDTH                          = " "0 (RET_PULSE_WIDTH_10US),1 (RET_PULSE_WIDTH_5US)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RET_CP_CAP_SIZE                          = " "0 (X1),1 (X1P5),2 (X2P5),3 (X4P5)"
    tree.end
    tree "LDO09_CONFIG_CTL1"
      sgroup "LDO09_CONFIG_CTL1 (at 0x14852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LV_BUFFER_EN                             = " "0 (LV_BUFFER_DISABLED),1 (LV_BUFFER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AMP_BIAS_TURBO                           = " "0 (AMP_BIAS_TURBO_DIS),1 (AMP_BIAS_TURBO_EN)"
    tree.end
    tree "LDO09_BYPASS_CTL1"
      sgroup "LDO09_BYPASS_CTL1 (at 0x14853)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIG_ASSISTED_BYPASS_EN                   = " "0 (DIG_BYPASS_DISABLED),1 (DIG_BYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO09_BYPASS_CTL2"
      sgroup "LDO09_BYPASS_CTL2 (at 0x14854)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BYPASS_ALLOWED                       = " "0 (DIG_BYPASS_NOT_ALLOWED),1 (DIG_BYPASS_ALLOWED)"
    tree.end
    tree "LDO09_STEPPER_CTL"
      sgroup "LDO09_STEPPER_CTL (at 0x14861)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0 (STEPPER_DIABLED),1 (STEPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_DELAY                               = " "0 (DELAY_2_CLK),1 (DELAY_4_CLK),2 (DELAY_8_CLK),3 (DELAY_16_CLK)"
    tree.end
    tree "LDO09_OCP_CTL1"
      sgroup "LDO09_OCP_CTL1 (at 0x14866)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO09_ULS_VSET_LB"
      sgroup "LDO09_ULS_VSET_LB (at 0x14868)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO09_ULS_VSET_UB"
      sgroup "LDO09_ULS_VSET_UB (at 0x14869)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO09_STATUS_DEB_CTL"
      sgroup "LDO09_STATUS_DEB_CTL (at 0x14870)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO09_ECM_EN_CTL"
      sgroup "LDO09_ECM_EN_CTL (at 0x14880)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_DIS),1 (ECM_LOCAL_EN)"
    tree.end
    tree "LDO09_ECM_CONFIG"
      sgroup "LDO09_ECM_CONFIG (at 0x14881)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "LDO09_ECM_DATA_LB"
      sgroup "LDO09_ECM_DATA_LB (at 0x14884)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "LDO09_ECM_DATA_UB"
      sgroup "LDO09_ECM_DATA_UB (at 0x14885)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "LDO09_SEC_ACCESS"
      sgroup "LDO09_SEC_ACCESS (at 0x148d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO09_PERPH_RESET_CTL1"
      sgroup "LDO09_PERPH_RESET_CTL1 (at 0x148d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO09_PERPH_RESET_CTL2"
      sgroup "LDO09_PERPH_RESET_CTL2 (at 0x148d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO09_PERPH_RESET_CTL3"
      sgroup "LDO09_PERPH_RESET_CTL3 (at 0x148da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO09_PERPH_RESET_CTL4"
      sgroup "LDO09_PERPH_RESET_CTL4 (at 0x148db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO09_INT_TEST1"
      sgroup "LDO09_INT_TEST1 (at 0x148e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO09_INT_TEST_VAL"
      sgroup "LDO09_INT_TEST_VAL (at 0x148e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO09_TEST1"
      sgroup "LDO09_TEST1 (at 0x148e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO09_TEST2"
      sgroup "LDO09_TEST2 (at 0x148e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (STEPPER_DONE_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_D_LDO_ENABLED_TO_BUCK_D_A2D_VREG_OK_DI),4 (D_D2A_LDO_VSET_DO_2_0),5 (D_A2D_RM_VREG_OK_DI_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (D_D2A_RET_MODE_EN_DO_D_A2D_RM_READY_DI_D_D2A_AMP_EN_DO),7 (D_A2D_RM_DISCHARGE_STS_DI_D_A2D_RM_CHARGE_STS_DI_D_A2D_ECM_COMP_DI)"
    tree.end
    tree "LDO09_TEST3"
      sgroup "LDO09_TEST3 (at 0x148e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_SELECT                                = " "0 (STEPPING_IN_SOFTSTART_EN),1 (STEPPING_IN_SOFTSTART_DIS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO09_ECM_TEST1"
      sgroup "LDO09_ECM_TEST1 (at 0x148e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "LDO09_ECM_TEST2"
      sgroup "LDO09_ECM_TEST2 (at 0x148e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "LDO09_TRIM_NUM"
      sgroup "LDO09_TRIM_NUM (at 0x148f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO09_TRIM_CTRL"
      sgroup "LDO09_TRIM_CTRL (at 0x148f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
    tree "LDO09_RM_TRIM_CTRL"
      sgroup "LDO09_RM_TRIM_CTRL (at 0x148f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        set &access:&cmd_addr %l 0x8048f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x48f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RM_TRIM_CTRL                             = "
    tree.end
  tree.end
tree.end
tree "LDO10"
  tree "LDO10"
    tree "LDO10_REVISION1"
      sgroup "LDO10_REVISION1 (at 0x14900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO10_REVISION2"
      sgroup "LDO10_REVISION2 (at 0x14901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO10_REVISION3"
      sgroup "LDO10_REVISION3 (at 0x14902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO10_REVISION4"
      sgroup "LDO10_REVISION4 (at 0x14903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO10_PERPH_TYPE"
      sgroup "LDO10_PERPH_TYPE (at 0x14904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO10_PERPH_SUBTYPE"
      sgroup "LDO10_PERPH_SUBTYPE (at 0x14905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO10_STATUS1"
      sgroup "LDO10_STATUS1 (at 0x14908)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO10_STATUS3"
      sgroup "LDO10_STATUS3 (at 0x1490a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80490a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x490a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO10_STATUS4"
      sgroup "LDO10_STATUS4 (at 0x1490b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80490b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x490b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
    tree.end
    tree "LDO10_INT_RT_STS"
      sgroup "LDO10_INT_RT_STS (at 0x14910)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO10_INT_SET_TYPE"
      sgroup "LDO10_INT_SET_TYPE (at 0x14911)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO10_INT_POLARITY_HIGH"
      sgroup "LDO10_INT_POLARITY_HIGH (at 0x14912)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO10_INT_POLARITY_LOW"
      sgroup "LDO10_INT_POLARITY_LOW (at 0x14913)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO10_INT_LATCHED_CLR"
      sgroup "LDO10_INT_LATCHED_CLR (at 0x14914)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO10_INT_EN_SET"
      sgroup "LDO10_INT_EN_SET (at 0x14915)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO10_INT_EN_CLR"
      sgroup "LDO10_INT_EN_CLR (at 0x14916)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO10_INT_LATCHED_STS"
      sgroup "LDO10_INT_LATCHED_STS (at 0x14918)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO10_INT_PENDING_STS"
      sgroup "LDO10_INT_PENDING_STS (at 0x14919)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO10_INT_MID_SEL"
      sgroup "LDO10_INT_MID_SEL (at 0x1491a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO10_INT_PRIORITY"
      sgroup "LDO10_INT_PRIORITY (at 0x1491b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x80491b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x491b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO10_VSET_LB"
      sgroup "LDO10_VSET_LB (at 0x14940)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO10_VSET_UB"
      sgroup "LDO10_VSET_UB (at 0x14941)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO10_VSET_VALID_LB"
      sgroup "LDO10_VSET_VALID_LB (at 0x14942)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO10_VSET_VALID_UB"
      sgroup "LDO10_VSET_VALID_UB (at 0x14943)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO10_MODE_CTL1"
      sgroup "LDO10_MODE_CTL1 (at 0x14945)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO10_EN_CTL"
      sgroup "LDO10_EN_CTL (at 0x14946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO10_FOLLOW_HWEN"
      sgroup "LDO10_FOLLOW_HWEN (at 0x14947)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO10_PD_CTL"
      sgroup "LDO10_PD_CTL (at 0x14948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO10_MODE_CTL2"
      sgroup "LDO10_MODE_CTL2 (at 0x14949)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO10_BYPASS_CTL1"
      sgroup "LDO10_BYPASS_CTL1 (at 0x14953)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO10_OCP_CTL1"
      sgroup "LDO10_OCP_CTL1 (at 0x14966)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO10_ULS_VSET_LB"
      sgroup "LDO10_ULS_VSET_LB (at 0x14968)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO10_ULS_VSET_UB"
      sgroup "LDO10_ULS_VSET_UB (at 0x14969)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO10_STATUS_DEB_CTL"
      sgroup "LDO10_STATUS_DEB_CTL (at 0x14970)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO10_SEC_ACCESS"
      sgroup "LDO10_SEC_ACCESS (at 0x149d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO10_PERPH_RESET_CTL1"
      sgroup "LDO10_PERPH_RESET_CTL1 (at 0x149d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL2"
      sgroup "LDO10_PERPH_RESET_CTL2 (at 0x149d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL3"
      sgroup "LDO10_PERPH_RESET_CTL3 (at 0x149da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO10_PERPH_RESET_CTL4"
      sgroup "LDO10_PERPH_RESET_CTL4 (at 0x149db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO10_INT_TEST1"
      sgroup "LDO10_INT_TEST1 (at 0x149e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO10_INT_TEST_VAL"
      sgroup "LDO10_INT_TEST_VAL (at 0x149e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO10_TEST1"
      sgroup "LDO10_TEST1 (at 0x149e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO10_TEST2"
      sgroup "LDO10_TEST2 (at 0x149e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (GROUND_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_SOFTSTART_DONE_D_A2D_VREG_OK_DI),4 (GROUND_D_D2A_BYPASS_EN_DO_D_A2D_VOUTOK_DI),5 (GROUND_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (GROUND_GROUND_D_D2A_AMP_EN_DO),7 (GROUND_GROUND_GROUND)"
    tree.end
    tree "LDO10_TEST3"
      sgroup "LDO10_TEST3 (at 0x149e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AB_PULL_DOWN_EN                          = " "0 (AB_PD_DISABLED),1 (AB_PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_VREF_BUF_EN                           = " "0 (SOFTSTART_VREF_BUF_DIS),1 (SOFTSTART_VREF_BUF_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO10_TRIM_NUM"
      sgroup "LDO10_TRIM_NUM (at 0x149f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO10_TRIM_CTRL"
      sgroup "LDO10_TRIM_CTRL (at 0x149f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        set &access:&cmd_addr %l 0x8049f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x49f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO11"
  tree "LDO11"
    tree "LDO11_REVISION1"
      sgroup "LDO11_REVISION1 (at 0x14a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO11_REVISION2"
      sgroup "LDO11_REVISION2 (at 0x14a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO11_REVISION3"
      sgroup "LDO11_REVISION3 (at 0x14a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO11_REVISION4"
      sgroup "LDO11_REVISION4 (at 0x14a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO11_PERPH_TYPE"
      sgroup "LDO11_PERPH_TYPE (at 0x14a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO11_PERPH_SUBTYPE"
      sgroup "LDO11_PERPH_SUBTYPE (at 0x14a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO11_STATUS1"
      sgroup "LDO11_STATUS1 (at 0x14a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO11_STATUS3"
      sgroup "LDO11_STATUS3 (at 0x14a0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO11_STATUS4"
      sgroup "LDO11_STATUS4 (at 0x14a0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
    tree.end
    tree "LDO11_INT_RT_STS"
      sgroup "LDO11_INT_RT_STS (at 0x14a10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO11_INT_SET_TYPE"
      sgroup "LDO11_INT_SET_TYPE (at 0x14a11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO11_INT_POLARITY_HIGH"
      sgroup "LDO11_INT_POLARITY_HIGH (at 0x14a12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO11_INT_POLARITY_LOW"
      sgroup "LDO11_INT_POLARITY_LOW (at 0x14a13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO11_INT_LATCHED_CLR"
      sgroup "LDO11_INT_LATCHED_CLR (at 0x14a14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO11_INT_EN_SET"
      sgroup "LDO11_INT_EN_SET (at 0x14a15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO11_INT_EN_CLR"
      sgroup "LDO11_INT_EN_CLR (at 0x14a16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO11_INT_LATCHED_STS"
      sgroup "LDO11_INT_LATCHED_STS (at 0x14a18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO11_INT_PENDING_STS"
      sgroup "LDO11_INT_PENDING_STS (at 0x14a19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO11_INT_MID_SEL"
      sgroup "LDO11_INT_MID_SEL (at 0x14a1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO11_INT_PRIORITY"
      sgroup "LDO11_INT_PRIORITY (at 0x14a1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO11_VSET_LB"
      sgroup "LDO11_VSET_LB (at 0x14a40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO11_VSET_UB"
      sgroup "LDO11_VSET_UB (at 0x14a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO11_VSET_VALID_LB"
      sgroup "LDO11_VSET_VALID_LB (at 0x14a42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO11_VSET_VALID_UB"
      sgroup "LDO11_VSET_VALID_UB (at 0x14a43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO11_MODE_CTL1"
      sgroup "LDO11_MODE_CTL1 (at 0x14a45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO11_EN_CTL"
      sgroup "LDO11_EN_CTL (at 0x14a46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO11_FOLLOW_HWEN"
      sgroup "LDO11_FOLLOW_HWEN (at 0x14a47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO11_PD_CTL"
      sgroup "LDO11_PD_CTL (at 0x14a48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO11_MODE_CTL2"
      sgroup "LDO11_MODE_CTL2 (at 0x14a49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO11_BYPASS_CTL1"
      sgroup "LDO11_BYPASS_CTL1 (at 0x14a53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO11_OCP_CTL1"
      sgroup "LDO11_OCP_CTL1 (at 0x14a66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO11_ULS_VSET_LB"
      sgroup "LDO11_ULS_VSET_LB (at 0x14a68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO11_ULS_VSET_UB"
      sgroup "LDO11_ULS_VSET_UB (at 0x14a69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO11_STATUS_DEB_CTL"
      sgroup "LDO11_STATUS_DEB_CTL (at 0x14a70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804a700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4a700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO11_SEC_ACCESS"
      sgroup "LDO11_SEC_ACCESS (at 0x14ad0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO11_PERPH_RESET_CTL1"
      sgroup "LDO11_PERPH_RESET_CTL1 (at 0x14ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL2"
      sgroup "LDO11_PERPH_RESET_CTL2 (at 0x14ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL3"
      sgroup "LDO11_PERPH_RESET_CTL3 (at 0x14ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO11_PERPH_RESET_CTL4"
      sgroup "LDO11_PERPH_RESET_CTL4 (at 0x14adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO11_INT_TEST1"
      sgroup "LDO11_INT_TEST1 (at 0x14ae0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO11_INT_TEST_VAL"
      sgroup "LDO11_INT_TEST_VAL (at 0x14ae1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO11_TEST1"
      sgroup "LDO11_TEST1 (at 0x14ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO11_TEST2"
      sgroup "LDO11_TEST2 (at 0x14ae3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (GROUND_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_SOFTSTART_DONE_D_A2D_VREG_OK_DI),4 (GROUND_D_D2A_BYPASS_EN_DO_D_A2D_VOUTOK_DI),5 (GROUND_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (GROUND_GROUND_D_D2A_AMP_EN_DO),7 (GROUND_GROUND_GROUND)"
    tree.end
    tree "LDO11_TEST3"
      sgroup "LDO11_TEST3 (at 0x14ae4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804ae40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ae40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AB_PULL_DOWN_EN                          = " "0 (AB_PD_DISABLED),1 (AB_PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_VREF_BUF_EN                           = " "0 (SOFTSTART_VREF_BUF_DIS),1 (SOFTSTART_VREF_BUF_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO11_TRIM_NUM"
      sgroup "LDO11_TRIM_NUM (at 0x14af0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO11_TRIM_CTRL"
      sgroup "LDO11_TRIM_CTRL (at 0x14af1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        set &access:&cmd_addr %l 0x804af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO12"
  tree "LDO12"
    tree "LDO12_REVISION1"
      sgroup "LDO12_REVISION1 (at 0x14b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO12_REVISION2"
      sgroup "LDO12_REVISION2 (at 0x14b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO12_REVISION3"
      sgroup "LDO12_REVISION3 (at 0x14b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO12_REVISION4"
      sgroup "LDO12_REVISION4 (at 0x14b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO12_PERPH_TYPE"
      sgroup "LDO12_PERPH_TYPE (at 0x14b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO12_PERPH_SUBTYPE"
      sgroup "LDO12_PERPH_SUBTYPE (at 0x14b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO12_STATUS1"
      sgroup "LDO12_STATUS1 (at 0x14b08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO12_STATUS3"
      sgroup "LDO12_STATUS3 (at 0x14b0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO12_STATUS4"
      sgroup "LDO12_STATUS4 (at 0x14b0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
    tree.end
    tree "LDO12_INT_RT_STS"
      sgroup "LDO12_INT_RT_STS (at 0x14b10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO12_INT_SET_TYPE"
      sgroup "LDO12_INT_SET_TYPE (at 0x14b11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO12_INT_POLARITY_HIGH"
      sgroup "LDO12_INT_POLARITY_HIGH (at 0x14b12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO12_INT_POLARITY_LOW"
      sgroup "LDO12_INT_POLARITY_LOW (at 0x14b13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO12_INT_LATCHED_CLR"
      sgroup "LDO12_INT_LATCHED_CLR (at 0x14b14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO12_INT_EN_SET"
      sgroup "LDO12_INT_EN_SET (at 0x14b15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO12_INT_EN_CLR"
      sgroup "LDO12_INT_EN_CLR (at 0x14b16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO12_INT_LATCHED_STS"
      sgroup "LDO12_INT_LATCHED_STS (at 0x14b18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO12_INT_PENDING_STS"
      sgroup "LDO12_INT_PENDING_STS (at 0x14b19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO12_INT_MID_SEL"
      sgroup "LDO12_INT_MID_SEL (at 0x14b1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO12_INT_PRIORITY"
      sgroup "LDO12_INT_PRIORITY (at 0x14b1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO12_VSET_LB"
      sgroup "LDO12_VSET_LB (at 0x14b40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO12_VSET_UB"
      sgroup "LDO12_VSET_UB (at 0x14b41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO12_VSET_VALID_LB"
      sgroup "LDO12_VSET_VALID_LB (at 0x14b42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO12_VSET_VALID_UB"
      sgroup "LDO12_VSET_VALID_UB (at 0x14b43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO12_MODE_CTL1"
      sgroup "LDO12_MODE_CTL1 (at 0x14b45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO12_EN_CTL"
      sgroup "LDO12_EN_CTL (at 0x14b46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO12_FOLLOW_HWEN"
      sgroup "LDO12_FOLLOW_HWEN (at 0x14b47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO12_PD_CTL"
      sgroup "LDO12_PD_CTL (at 0x14b48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO12_MODE_CTL2"
      sgroup "LDO12_MODE_CTL2 (at 0x14b49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO12_BYPASS_CTL1"
      sgroup "LDO12_BYPASS_CTL1 (at 0x14b53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO12_OCP_CTL1"
      sgroup "LDO12_OCP_CTL1 (at 0x14b66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO12_ULS_VSET_LB"
      sgroup "LDO12_ULS_VSET_LB (at 0x14b68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO12_ULS_VSET_UB"
      sgroup "LDO12_ULS_VSET_UB (at 0x14b69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO12_STATUS_DEB_CTL"
      sgroup "LDO12_STATUS_DEB_CTL (at 0x14b70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804b700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO12_SEC_ACCESS"
      sgroup "LDO12_SEC_ACCESS (at 0x14bd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO12_PERPH_RESET_CTL1"
      sgroup "LDO12_PERPH_RESET_CTL1 (at 0x14bd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL2"
      sgroup "LDO12_PERPH_RESET_CTL2 (at 0x14bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL3"
      sgroup "LDO12_PERPH_RESET_CTL3 (at 0x14bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO12_PERPH_RESET_CTL4"
      sgroup "LDO12_PERPH_RESET_CTL4 (at 0x14bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO12_INT_TEST1"
      sgroup "LDO12_INT_TEST1 (at 0x14be0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO12_INT_TEST_VAL"
      sgroup "LDO12_INT_TEST_VAL (at 0x14be1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO12_TEST1"
      sgroup "LDO12_TEST1 (at 0x14be2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO12_TEST2"
      sgroup "LDO12_TEST2 (at 0x14be3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (GROUND_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_SOFTSTART_DONE_D_A2D_VREG_OK_DI),4 (GROUND_D_D2A_BYPASS_EN_DO_D_A2D_VOUTOK_DI),5 (GROUND_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (GROUND_GROUND_D_D2A_AMP_EN_DO),7 (GROUND_GROUND_GROUND)"
    tree.end
    tree "LDO12_TEST3"
      sgroup "LDO12_TEST3 (at 0x14be4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804be40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AB_PULL_DOWN_EN                          = " "0 (AB_PD_DISABLED),1 (AB_PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_VREF_BUF_EN                           = " "0 (SOFTSTART_VREF_BUF_DIS),1 (SOFTSTART_VREF_BUF_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO12_TRIM_NUM"
      sgroup "LDO12_TRIM_NUM (at 0x14bf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO12_TRIM_CTRL"
      sgroup "LDO12_TRIM_CTRL (at 0x14bf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        set &access:&cmd_addr %l 0x804bf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LDO13"
  tree "LDO13"
    tree "LDO13_REVISION1"
      sgroup "LDO13_REVISION1 (at 0x14c00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LDO13_REVISION2"
      sgroup "LDO13_REVISION2 (at 0x14c01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LDO13_REVISION3"
      sgroup "LDO13_REVISION3 (at 0x14c02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LDO13_REVISION4"
      sgroup "LDO13_REVISION4 (at 0x14c03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LDO13_PERPH_TYPE"
      sgroup "LDO13_PERPH_TYPE (at 0x14c04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LDO13_PERPH_SUBTYPE"
      sgroup "LDO13_PERPH_SUBTYPE (at 0x14c05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LDO13_STATUS1"
      sgroup "LDO13_STATUS1 (at 0x14c08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (LDO_NO_ERR),1 (LDO_ERR)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_OCP),1 (OCP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NOT_LDO_ON_OR_NOT_NPM),1 (LDO_ON_NPM)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_NOT_DONE),1 (STEPPER_DONE)"
    tree.end
    tree "LDO13_STATUS3"
      sgroup "LDO13_STATUS3 (at 0x14c0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EA_OUTPUT                                = " "0 (EA_OUT_LOW),1 (EA_OUT_HIGH)"
    tree.end
    tree "LDO13_STATUS4"
      sgroup "LDO13_STATUS4 (at 0x14c0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
    tree.end
    tree "LDO13_INT_RT_STS"
      sgroup "LDO13_INT_RT_STS (at 0x14c10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (LDO_NOT_READY),1 (LDO_READY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (LDO_NO_FAULT),1 (LDO_FAULT)"
    tree.end
    tree "LDO13_INT_SET_TYPE"
      sgroup "LDO13_INT_SET_TYPE (at 0x14c11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "LDO13_INT_POLARITY_HIGH"
      sgroup "LDO13_INT_POLARITY_HIGH (at 0x14c12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "LDO13_INT_POLARITY_LOW"
      sgroup "LDO13_INT_POLARITY_LOW (at 0x14c13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "LDO13_INT_LATCHED_CLR"
      sgroup "LDO13_INT_LATCHED_CLR (at 0x14c14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "LDO13_INT_EN_SET"
      sgroup "LDO13_INT_EN_SET (at 0x14c15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "LDO13_INT_EN_CLR"
      sgroup "LDO13_INT_EN_CLR (at 0x14c16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "LDO13_INT_LATCHED_STS"
      sgroup "LDO13_INT_LATCHED_STS (at 0x14c18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "LDO13_INT_PENDING_STS"
      sgroup "LDO13_INT_PENDING_STS (at 0x14c19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "LDO13_INT_MID_SEL"
      sgroup "LDO13_INT_MID_SEL (at 0x14c1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_SEL_0),1 (INT_MID_SEL_1),2 (reserved),3 (reserved)"
    tree.end
    tree "LDO13_INT_PRIORITY"
      sgroup "LDO13_INT_PRIORITY (at 0x14c1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR),1 (INT_PRIORITY_A)"
    tree.end
    tree "LDO13_VSET_LB"
      sgroup "LDO13_VSET_LB (at 0x14c40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "LDO13_VSET_UB"
      sgroup "LDO13_VSET_UB (at 0x14c41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "LDO13_VSET_VALID_LB"
      sgroup "LDO13_VSET_VALID_LB (at 0x14c42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   VSET_VALID_LB                            = "
    tree.end
    tree "LDO13_VSET_VALID_UB"
      sgroup "LDO13_VSET_VALID_UB (at 0x14c43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "LDO13_MODE_CTL1"
      sgroup "LDO13_MODE_CTL1 (at 0x14c45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO13_EN_CTL"
      sgroup "LDO13_EN_CTL (at 0x14c46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_LDO_INT                               = " "0 (EN_LDO_INT_FALSE),1 (EN_LDO_INT_TRUE)"
    tree.end
    tree "LDO13_FOLLOW_HWEN"
      sgroup "LDO13_FOLLOW_HWEN (at 0x14c47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FOLLOW_PMIC_AWAKE                   = " "0 (MODE_FOLLOW_PMIC_AWAKE_FALSE),1 (MODE_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MODE_FOLLOW_HW_EN2                       = " "0 (MODE_FOLLOW_HW_EN2_FALSE),1 (MODE_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MODE_FOLLOW_HW_EN1                       = " "0 (MODE_FOLLOW_HW_EN1_FALSE),1 (MODE_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MODE_FOLLOW_HW_EN0                       = " "0 (MODE_FOLLOW_HW_EN0_FALSE),1 (MODE_FOLLOW_HW_EN0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HW_EN2                         = " "0 (EN_FOLLOW_HW_EN2_FALSE),1 (EN_FOLLOW_HW_EN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HW_EN1                         = " "0 (EN_FOLLOW_HW_EN1_FALSE),1 (EN_FOLLOW_HW_EN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HW_EN0                         = " "0 (EN_FOLLOW_HW_EN0_FALSE),1 (EN_FOLLOW_HW_EN0_TRUE)"
    tree.end
    tree "LDO13_PD_CTL"
      sgroup "LDO13_PD_CTL (at 0x14c48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ALWAYS_OFF),1 (STRONG_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_DISABLED),1 (WEAK_PD_WHEN_LDO_IS_OFF)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAKAGE_PD_ALWAYS_DISABLED),1 (LEAKAGE_PD_ALWAYS_ENABLED)"
    tree.end
    tree "LDO13_MODE_CTL2"
      sgroup "LDO13_MODE_CTL2 (at 0x14c49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (UNUSED_0),1 (ACTIVE_BYPASS_LPM),2 (ACTIVE_BYPASS_NPM),3 (FORCED_BYPASS),4 (RETENTION),5 (LPM),6 (UNUSED_6),7 (NPM)"
    tree.end
    tree "LDO13_BYPASS_CTL1"
      sgroup "LDO13_BYPASS_CTL1 (at 0x14c53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ANA_AUTOBYPASS_EN                        = " "0 (ANA_AUTOBYPASS_DISABLED),1 (ANA_AUTOBYPASS_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ANA_AUTOBYPASS_THR                       = " "0, 1, 2, 3"
    tree.end
    tree "LDO13_OCP_CTL1"
      sgroup "LDO13_OCP_CTL1 (at 0x14c66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OCP_EN                                   = " "0 (OCP_DISABLED),1 (OCP_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_SELF_SHUTDOWN_EN                     = " "0 (OCP_SELF_SHUTDOWN_DISABLED),1 (OCP_SELF_SHUTDOWN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OCP_DEB                                  = " "0 (DEB_4_SCLK),1 (DEB_8_SCLK),2 (DEB_16_SCLK),3 (DEB_32_SCLK)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_DISABLED),1 (OCP_GLOBAL_BROADCAST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OCP_TESTMODE_EN                          = " "0 (OCP_TESTMODE_DISABLED),1 (OCP_TESTMODE_ENABLED)"
    tree.end
    tree "LDO13_ULS_VSET_LB"
      sgroup "LDO13_ULS_VSET_LB (at 0x14c68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "LDO13_ULS_VSET_UB"
      sgroup "LDO13_ULS_VSET_UB (at 0x14c69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "LDO13_STATUS_DEB_CTL"
      sgroup "LDO13_STATUS_DEB_CTL (at 0x14c70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804c700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4c700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_1_2_SCLK),1 (READY_DEB_2_3_SCLK),2 (READY_DEB_4_5_SCLK),3 (READY_DEB_3_4_SCLK)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_1_2_SCLK),1 (ERROR_DEB_2_3_SCLK),2 (ERROR_DEB_4_5_SCLK),3 (ERROR_DEB_3_4_SCLK)"
    tree.end
    tree "LDO13_SEC_ACCESS"
      sgroup "LDO13_SEC_ACCESS (at 0x14cd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LDO13_PERPH_RESET_CTL1"
      sgroup "LDO13_PERPH_RESET_CTL1 (at 0x14cd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL2"
      sgroup "LDO13_PERPH_RESET_CTL2 (at 0x14cd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL3"
      sgroup "LDO13_PERPH_RESET_CTL3 (at 0x14cda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "LDO13_PERPH_RESET_CTL4"
      sgroup "LDO13_PERPH_RESET_CTL4 (at 0x14cdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "LDO13_INT_TEST1"
      sgroup "LDO13_INT_TEST1 (at 0x14ce0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "LDO13_INT_TEST_VAL"
      sgroup "LDO13_INT_TEST_VAL (at 0x14ce1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TEST_VAL                      = " "0 (VREG_READY_TEST_VAL_0),1 (VREG_READY_TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TEST_VAL                      = " "0 (VREG_FAULT_TEST_VAL_0),1 (VREG_FAULT_TEST_VAL_1)"
    tree.end
    tree "LDO13_TEST1"
      sgroup "LDO13_TEST1 (at 0x14ce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ATEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ATEST1                                   = "
    tree.end
    tree "LDO13_TEST2"
      sgroup "LDO13_TEST2 (at 0x14ce3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   I_TST_EN                                 = " "0 (I_TST_DISABLED),1 (I_TST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0 (GROUND),1 (GROUND_D_A2D_BIAS_READY_A_DI_ENABLE_LDO),2 (D_D2A_BUFF_EN_DO_D_D2A_NPM_EN_DO_D_D2A_LPM_EN_DO),3 (OCP_DETECT_SHUTDOWN_LDO_SOFTSTART_DONE_D_A2D_VREG_OK_DI),4 (GROUND_D_D2A_BYPASS_EN_DO_D_A2D_VOUTOK_DI),5 (GROUND_D_A2D_LOW_HR_DETECTED_DI_D_D2A_VSENSE_EN_DO),6 (GROUND_GROUND_D_D2A_AMP_EN_DO),7 (GROUND_GROUND_GROUND)"
    tree.end
    tree "LDO13_TEST3"
      sgroup "LDO13_TEST3 (at 0x14ce4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804ce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4ce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AB_PULL_DOWN_EN                          = " "0 (AB_PD_DISABLED),1 (AB_PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SS_VREF_BUF_EN                           = " "0 (SOFTSTART_VREF_BUF_DIS),1 (SOFTSTART_VREF_BUF_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PBS_TRIM_EN                              = " "0 (PBS_TRIM_DISABLED),1 (PBS_TRIM_ENABLED)"
    tree.end
    tree "LDO13_TRIM_NUM"
      sgroup "LDO13_TRIM_NUM (at 0x14cf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "LDO13_TRIM_CTRL"
      sgroup "LDO13_TRIM_CTRL (at 0x14cf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        set &access:&cmd_addr %l 0x804cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x4c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_CTRL                                = "
    tree.end
  tree.end
tree.end
tree "LN_BB_CLK"
  tree "LN_BB_CLK"
    tree "LN_BB_CLK_REVISION1"
      sgroup "LN_BB_CLK_REVISION1 (at 0x5800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION2"
      sgroup "LN_BB_CLK_REVISION2 (at 0x5801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION3"
      sgroup "LN_BB_CLK_REVISION3 (at 0x5802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "LN_BB_CLK_REVISION4"
      sgroup "LN_BB_CLK_REVISION4 (at 0x5803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "LN_BB_CLK_PERPH_TYPE"
      sgroup "LN_BB_CLK_PERPH_TYPE (at 0x5804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "LN_BB_CLK_PERPH_SUBTYPE"
      sgroup "LN_BB_CLK_PERPH_SUBTYPE (at 0x5805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "LN_BB_CLK_STATUS1"
      sgroup "LN_BB_CLK_STATUS1 (at 0x5808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (BBCLK_OFF),1 (BBCLK_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLK_ENA_HOLD                             = " "0 (RFCLK_UNLATCH),1 (RFCLK_LATCH)"
    tree.end
    tree "LN_BB_CLK_EDGE_CTL1"
      sgroup "LN_BB_CLK_EDGE_CTL1 (at 0x5843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_EDGE                                 = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "LN_BB_CLK_DRV_CTL1"
      sgroup "LN_BB_CLK_DRV_CTL1 (at 0x5844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "LN_BB_CLK_CLKBUFF_HOLD_CTL"
      sgroup "LN_BB_CLK_CLKBUFF_HOLD_CTL (at 0x5845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLKBUFF_HOLD                             = "
    tree.end
    tree "LN_BB_CLK_EN_CTL"
      sgroup "LN_BB_CLK_EN_CTL (at 0x5846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (BBCLK_NOT_FORCE),1 (BBCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "LN_BB_CLK_CLK_EN_CTL"
      sgroup "LN_BB_CLK_CLK_EN_CTL (at 0x5847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "LN_BB_CLK_PD_CTL"
      sgroup "LN_BB_CLK_PD_CTL (at 0x5848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "LN_BB_CLK_TIMER"
      sgroup "LN_BB_CLK_TIMER (at 0x584c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x80584c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x584c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DELAY                                    = "
    tree.end
    tree "LN_BB_CLK_SEC_ACCESS"
      sgroup "LN_BB_CLK_SEC_ACCESS (at 0x58d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL1"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL1 (at 0x58d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL2"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL2 (at 0x58d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL3"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL3 (at 0x58da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "LN_BB_CLK_PERPH_RESET_CTL4"
      sgroup "LN_BB_CLK_PERPH_RESET_CTL4 (at 0x58db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "LN_BB_CLK_TEST1"
      sgroup "LN_BB_CLK_TEST1 (at 0x58e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TEST_EN                          = " "0 (CLKBUFF_DISA),1 (CLKBUFF_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_EN                                 = " "0 (ATEST_HI_Z),1 (CLK_DC_DFT)"
    tree.end
    tree "LN_BB_CLK_TEST2"
      sgroup "LN_BB_CLK_TEST2 (at 0x58e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OUTBUFF_TIMING                           = " "0 (SINGLE_CLK),1 (DOUBLE_CLK)"
    tree.end
    tree "LN_BB_CLK_TEST3"
      sgroup "LN_BB_CLK_TEST3 (at 0x58e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        set &access:&cmd_addr %l 0x8058e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x58e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TO_DTEST                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLKBUFF_DRIVE_EN                         = " "0 (DISABLE),1 (ENABLE)"
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0 (MBG_NOT_OK),1 (MBG_IS_OK)"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STARTUP_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CC_EN                                    = " "0 (CC_DISABLED),1 (CC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TEMP_COMP_OFFSET_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBG_OK_DELAY                             = " "0, 1"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0, 1"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MANUAL_CAL_MODE                          = " "0, 1"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_VREF_0P625_OFF                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VREF_0P3125_OFF                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FORCE_MBG_OK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   FORCE_STARTUP_EN                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CC_CAL_HI_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CC_CAL_LO_EN                             = " "0, 1"
    tree.end
    tree "MBG1_AUTOCAL_CTRL"
      sgroup "MBG1_AUTOCAL_CTRL (at 0x2ce4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MBG_TEMP_CAL_CTRL                        = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   AUTO_CAL_CLK_CTRL                        = " "0 (CAL_CLK_CTRL0),1 (CAL_CLK_CTRL1),2 (CAL_CLK_CTRL2),3 (CAL_CLK_CTRL3)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AUTOCAL_CAL_EN                           = " "0, 1"
    tree.end
    tree "MBG1_AUTOCAL_RD1"
      sgroup "MBG1_AUTOCAL_RD1 (at 0x2ce5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AUTOCAL_DONE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTOCAL_FAULT                            = " "0, 1"
    tree.end
    tree "MBG1_AUTOCAL_RD2"
      sgroup "MBG1_AUTOCAL_RD2 (at 0x2ce6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   AUTOCAL_CODE                             = "
    tree.end
    tree "MBG1_TEST_MBG_OK_OFFSET"
      sgroup "MBG1_TEST_MBG_OK_OFFSET (at 0x2ce7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   MBG_OK_OFFSET_CTRL                       = "
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VREF_1P25_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TEMP_COMP_OFFSET_TRIM                    = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VREF_0P625_TRIM                          = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VREF_0P3125_TRIM                         = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IREF_GEN_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IPTAT_GEN_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VTEMP_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VTEMP_REF_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM9"
      sgroup "MBG1_MBG_TRIM9 (at 0x2cf9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VTEMP_BUF_TRIM                           = "
    tree.end
    tree "MBG1_MBG_TRIM10"
      sgroup "MBG1_MBG_TRIM10 (at 0x2cfa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IREF_TEMP_TRIM                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_MBG_TRIM11"
      sgroup "MBG1_MBG_TRIM11 (at 0x2cfb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG_TEMP_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM12"
      sgroup "MBG1_MBG_TRIM12 (at 0x2cfc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CC_GAIN_TRIM                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_MBG_TRIM13"
      sgroup "MBG1_MBG_TRIM13 (at 0x2cfd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CC_HI_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM14"
      sgroup "MBG1_MBG_TRIM14 (at 0x2cfe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cfe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cfe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CC_LO_TRIM                               = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS2"
      sgroup "MISC_STATUS2 (at 0x909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST                                    = "
    tree.end
    tree "MISC_STATUS4"
      sgroup "MISC_STATUS4 (at 0x90b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80090b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x90b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (DATA_NOT_OVERWRITTEN),1 (DATA_OVERWRITTEN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_NOT_PRESENT),1 (ECM_PRESENT)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
    tree.end
    tree "MISC_TEST_CONNECT"
      sgroup "MISC_TEST_CONNECT (at 0x940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST_CONN_8_4                           = " "0 (DTEST_CONNECT_8_TO_4_DISABLED),1 (DTEST_CONNECT_8_TO_4_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST_CONN_7_3                           = " "0 (DTEST_CONNECT_7_TO_3_DISABLED),1 (DTEST_CONNECT_7_TO_3_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST_CONN_6_2                           = " "0 (DTEST_CONNECT_6_TO_2_DISABLED),1 (DTEST_CONNECT_6_TO_2_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST_CONN_5_1                           = " "0 (DTEST_CONNECT_5_TO_1_DISABLED),1 (DTEST_CONNECT_5_TO_1_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_CONN_4_8                           = " "0 (DTEST_CONNECT_4_TO_8_DISABLED),1 (DTEST_CONNECT_4_TO_8_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_CONN_3_7                           = " "0 (DTEST_CONNECT_3_TO_7_DISABLED),1 (DTEST_CONNECT_3_TO_7_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST_CONN_2_6                           = " "0 (DTEST_CONNECT_2_TO_6_DISABLED),1 (DTEST_CONNECT_2_TO_6_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_CONN_1_5                           = " "0 (DTEST_CONNECT_1_TO_5_DISABLED),1 (DTEST_CONNECT_1_TO_5_ENABLED)"
    tree.end
    tree "MISC_DTEST_DRV_CTL"
      sgroup "MISC_DTEST_DRV_CTL (at 0x943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST8_DRV_EN                            = " "0 (DTEST8_DRV_DISABLED),1 (DTEST8_DRV_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST7_DRV_EN                            = " "0 (DTEST7_DRV_DISABLED),1 (DTEST7_DRV_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST6_DRV_EN                            = " "0 (DTEST6_DRV_DISABLED),1 (DTEST6_DRV_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST5_DRV_EN                            = " "0 (DTEST5_DRV_DISABLED),1 (DTEST5_DRV_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4_DRV_EN                            = " "0 (DTEST4_DRV_DISABLED),1 (DTEST4_DRV_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3_DRV_EN                            = " "0 (DTEST3_DRV_DISABLED),1 (DTEST3_DRV_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2_DRV_EN                            = " "0 (DTEST2_DRV_DISABLED),1 (DTEST2_DRV_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1_DRV_EN                            = " "0 (DTEST1_DRV_DISABLED),1 (DTEST1_DRV_ENABLED)"
    tree.end
    tree "MISC_DTEST_DRV_VAL"
      sgroup "MISC_DTEST_DRV_VAL (at 0x944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST8_VAL                               = " "0 (DTEST8_VAL_LOW),1 (DTEST8_VAL_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST7_VAL                               = " "0 (DTEST7_VAL_LOW),1 (DTEST7_VAL_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST6_VAL                               = " "0 (DTEST6_VAL_LOW),1 (DTEST6_VAL_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST5_VAL                               = " "0 (DTEST5_VAL_LOW),1 (DTEST5_VAL_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4_VAL                               = " "0 (DTEST4_VAL_LOW),1 (DTEST4_VAL_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3_VAL                               = " "0 (DTEST3_VAL_LOW),1 (DTEST3_VAL_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2_VAL                               = " "0 (DTEST2_VAL_LOW),1 (DTEST2_VAL_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1_VAL                               = " "0 (DTEST1_VAL_LOW),1 (DTEST1_VAL_HIGH)"
    tree.end
    tree "MISC_MISC_CTL1"
      sgroup "MISC_MISC_CTL1 (at 0x946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_VREF_BUFF_0P3                         = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   EN_VREF_BUFF_0P6                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_GP1RESET_CTL1"
      sgroup "MISC_GP1RESET_CTL1 (at 0x947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GP1RESET_POLARITY                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GP1RESET_PON_SEL                         = " "0, 1"
    tree.end
    tree "MISC_GP2RESET_CTL1"
      sgroup "MISC_GP2RESET_CTL1 (at 0x948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GP2RESET_POLARITY                        = " "0, 1"
    tree.end
    tree "MISC_PWM_SEL"
      sgroup "MISC_PWM_SEL (at 0x949)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_SEL                                  = " "0 (ZERO),1 (PWM1),2 (PWM2),3 (PWM1_AND_PWM2)"
    tree.end
    tree "MISC_SEL_BI"
      sgroup "MISC_SEL_BI (at 0x94a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SEL_BI                                   = " "0, 1"
    tree.end
    tree "MISC_FORCE_PWM_EN"
      sgroup "MISC_FORCE_PWM_EN (at 0x94b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BUCK_FORCE_PWM_ENABLE                    = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_GP_DRIVER_EN"
      sgroup "MISC_GP_DRIVER_EN (at 0x94c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GP_DRIVER_ENABLE                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_MISC_CTL2"
      sgroup "MISC_MISC_CTL2 (at 0x94d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MISC_CTL2                                = "
    tree.end
    tree "MISC_RF_CLK_LDO_HW_EN"
      sgroup "MISC_RF_CLK_LDO_HW_EN (at 0x970)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RF_CLK3_SEL                              = " "0 (BUFFER),1 (PIN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_CLK2_SEL                              = " "0 (BUFFER),1 (PIN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_CLK1_SEL                              = " "0 (BUFFER),1 (PIN)"
    tree.end
    tree "MISC_LB_BCLK_LDO_HW_EN"
      sgroup "MISC_LB_BCLK_LDO_HW_EN (at 0x971)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LB_BCLK1_SEL                             = " "0 (BUFFER),1 (PIN)"
    tree.end
    tree "MISC_ECM_EN_CTL"
      sgroup "MISC_ECM_EN_CTL (at 0x980)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_NOT_FORCED_ON),1 (ECM_FORCED_ON)"
    tree.end
    tree "MISC_ECM_CONFIG"
      sgroup "MISC_ECM_CONFIG (at 0x981)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OFFSET_SAMPLING_PULSE_WIDTH              = " "0 (OS_PW_2_CLKS),1 (OS_PW_4_CLKS),2 (OS_PW_8_CLKS),3 (OS_PW_16_CLKS)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CHOPPING_FREQ_DIV                        = " "0 (DIV_64),1 (DIV_128),2 (DIV_256),3 (DIV_512)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DYNAMIC_BIAS_EN                          = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CM_VOLTAGE                               = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ECM_DATA_LB"
      sgroup "MISC_ECM_DATA_LB (at 0x984)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "MISC_ECM_DATA_UB"
      sgroup "MISC_ECM_DATA_UB (at 0x985)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "MISC_ANA_BUF1_EN_CTL"
      sgroup "MISC_ANA_BUF1_EN_CTL (at 0x9c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_ANA_BUF2_EN_CTL"
      sgroup "MISC_ANA_BUF2_EN_CTL (at 0x9c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_ANA_BUF3_EN_CTL"
      sgroup "MISC_ANA_BUF3_EN_CTL (at 0x9c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_ANA_BUF4_EN_CTL"
      sgroup "MISC_ANA_BUF4_EN_CTL (at 0x9c3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009c30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9c30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CTL                                   = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0, 1"
    tree.end
    tree "MISC_ANA_IN1_SEL"
      sgroup "MISC_ANA_IN1_SEL (at 0x9e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ANA_IN2_SEL"
      sgroup "MISC_ANA_IN2_SEL (at 0x9e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ANA_IN3_SEL"
      sgroup "MISC_ANA_IN3_SEL (at 0x9e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ANA_IN4_SEL"
      sgroup "MISC_ANA_IN4_SEL (at 0x9e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AIN_SEL                                  = " "0, 1, 2, 3"
    tree.end
    tree "MISC_ECM_TEST1"
      sgroup "MISC_ECM_TEST1 (at 0x9e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_SENSE_OS_EN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ECM_SENSE_CHOP_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ECM_SENSE_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_ADC_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_CURRENT_MIRROR_EN                    = " "0, 1"
    tree.end
    tree "MISC_ECM_TEST2"
      sgroup "MISC_ECM_TEST2 (at 0x9e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MISC_ANA_OUT1_SEL"
      sgroup "MISC_ANA_OUT1_SEL (at 0x9e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "MISC_ANA_OUT2_SEL"
      sgroup "MISC_ANA_OUT2_SEL (at 0x9ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST1),1 (ATEST2),2 (ATEST3),3 (ATEST4)"
    tree.end
    tree "MISC_ANA_OUT3_SEL"
      sgroup "MISC_ANA_OUT3_SEL (at 0x9eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST5),1 (ATEST6),2 (ATEST7),3 (ATEST8)"
    tree.end
    tree "MISC_ANA_OUT4_SEL"
      sgroup "MISC_ANA_OUT4_SEL (at 0x9ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AOUT_SEL                                 = " "0 (ATEST5),1 (ATEST6),2 (ATEST7),3 (ATEST8)"
    tree.end
    tree "MISC_TEST1"
      sgroup "MISC_TEST1 (at 0x9ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MISC_BIST_TEST"
      sgroup "MISC_BIST_TEST (at 0x9ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BIST_TEST_EN                             = " "0 (DISABLED),1 (ENABLED)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_STATUS1"
      sgroup "PBS_CLIENT0_STATUS1 (at 0x7109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT0_TRIG_LATCHED"
      sgroup "PBS_CLIENT0_TRIG_LATCHED (at 0x710a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80710a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x710a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT0_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT0_HW_TRIG_RE_EN (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT0_HW_TRIG_FE_EN (at 0x7141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT0_TRIG_LATCHED_CLR (at 0x7148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
    tree.end
    tree "PBS_CLIENT0_SCRATCH1"
      sgroup "PBS_CLIENT0_SCRATCH1 (at 0x7150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT0_SCRATCH2"
      sgroup "PBS_CLIENT0_SCRATCH2 (at 0x7151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_STATUS1"
      sgroup "PBS_CLIENT1_STATUS1 (at 0x7209)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT1_TRIG_LATCHED"
      sgroup "PBS_CLIENT1_TRIG_LATCHED (at 0x720a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80720a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x720a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT1_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT1_HW_TRIG_RE_EN (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT1_HW_TRIG_FE_EN (at 0x7241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT1_TRIG_LATCHED_CLR (at 0x7248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
    tree.end
    tree "PBS_CLIENT1_SCRATCH1"
      sgroup "PBS_CLIENT1_SCRATCH1 (at 0x7250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT1_SCRATCH2"
      sgroup "PBS_CLIENT1_SCRATCH2 (at 0x7251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "PBS_CLIENT1_CHAN_SEL"
      sgroup "PBS_CLIENT1_CHAN_SEL (at 0x72e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_TRIG_EN                            = " "0 (DTEST_TRIGGER_OFF),1 (DTEST_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_TRIG_SEL                           = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_STATUS1"
      sgroup "PBS_CLIENT2_STATUS1 (at 0x7309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT2_TRIG_LATCHED"
      sgroup "PBS_CLIENT2_TRIG_LATCHED (at 0x730a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80730a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x730a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT2_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT2_HW_TRIG_RE_EN (at 0x7340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT2_HW_TRIG_FE_EN (at 0x7341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT2_TRIG_LATCHED_CLR (at 0x7348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
    tree.end
    tree "PBS_CLIENT2_SCRATCH1"
      sgroup "PBS_CLIENT2_SCRATCH1 (at 0x7350)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT2_SCRATCH2"
      sgroup "PBS_CLIENT2_SCRATCH2 (at 0x7351)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "PBS_CLIENT2_CHAN_SEL"
      sgroup "PBS_CLIENT2_CHAN_SEL (at 0x73e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_TRIG_EN                            = " "0 (DTEST_TRIGGER_OFF),1 (DTEST_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_TRIG_SEL                           = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIG_EN_STATUS                        = " "0 (HW_CLIENT_DISABLED),1 (HW_CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_STATUS1"
      sgroup "PBS_CLIENT3_STATUS1 (at 0x7409)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0 (EXECUTING),1 (NORMAL_COMPLETION),2 (ERROR_COMPLETION),3 (ABORT_COMPLETION)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TRIG_FSM_STATUS                          = "
    tree.end
    tree "PBS_CLIENT3_TRIG_LATCHED"
      sgroup "PBS_CLIENT3_TRIG_LATCHED (at 0x740a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80740a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x740a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT                           = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT                            = " "0 (NOT_LATCHED),1 (LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PBS_CLIENT3_HW_TRIG_RE_EN"
      sgroup "PBS_CLIENT3_HW_TRIG_RE_EN (at 0x7440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (RISING_EDGE_TRIGGER_IGNORED),1 (RISING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_HW_TRIG_FE_EN"
      sgroup "PBS_CLIENT3_HW_TRIG_FE_EN (at 0x7441)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_EN                             = " "0 (FALLING_EDGE_TRIGGER_IGNORED),1 (FALLING_EDGE_TRIGGER_ARMED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_SET                        = " "0 (NO_OPERATION),1 (SET_LATCH)"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0 (CLIENT_DISABLED),1 (CLIENT_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_TRIG_LATCHED_CLR"
      sgroup "PBS_CLIENT3_TRIG_LATCHED_CLR (at 0x7448)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_TRIGGER_LAT_CLR                       = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIGGER_3_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIGGER_2_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
