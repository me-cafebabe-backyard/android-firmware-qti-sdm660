      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIGGER_1_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIGGER_0_LAT_CLR                        = " "0 (NO_OPERATION),1 (CLR_LATCH)"
    tree.end
    tree "PBS_CLIENT3_SCRATCH1"
      sgroup "PBS_CLIENT3_SCRATCH1 (at 0x7450)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT3_SCRATCH2"
      sgroup "PBS_CLIENT3_SCRATCH2 (at 0x7451)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "PBS_CLIENT3_CHAN_SEL"
      sgroup "PBS_CLIENT3_CHAN_SEL (at 0x74e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_TRIG_EN                            = " "0 (DTEST_TRIGGER_OFF),1 (DTEST_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_TRIG_SEL                           = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0 (RESERVED),1 (NORMAL),2 (ERROR),3 (ABORT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0 (SINGLE_MODE),1 (BURST_MODE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0 (READ_ACCESS),1 (WRITE_ACCESS)"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_TRIG_STATUS0"
      sgroup "PBS_CORE_TRIG_STATUS0 (at 0x7098)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LAST_TRIG_3_COMP                         = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LAST_TRIG_2_COMP                         = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LAST_TRIG_1_COMP                         = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LAST_TRIG_0_COMP                         = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
    tree.end
    tree "PBS_CORE_TRIG_STATUS1"
      sgroup "PBS_CORE_TRIG_STATUS1 (at 0x7099)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_3_IN_SERVICE                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIG_2_IN_SERVICE                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TRIG_1_IN_SERVICE                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIG_0_IN_SERVICE                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LAST_TRIG_3_NORMAL                       = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LAST_TRIG_2_NORMAL                       = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LAST_TRIG_1_NORMAL                       = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LAST_TRIG_0_NORMAL                       = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
    tree.end
    tree "PBS_CORE_TRIG_STATUS2"
      sgroup "PBS_CORE_TRIG_STATUS2 (at 0x709a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80709a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x709a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   LAST_TRIG_3_ABORTED                      = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LAST_TRIG_2_ABORTED                      = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   LAST_TRIG_1_ABORTED                      = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LAST_TRIG_0_ABORTED                      = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LAST_TRIG_3_ERROR                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LAST_TRIG_2_ERROR                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LAST_TRIG_1_ERROR                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LAST_TRIG_0_ERROR                        = " "0 (HW_TRIGGER_OFF),1 (HW_TRIGGER_ON)"
    tree.end
    tree "PBS_CORE_RAM_CFG1"
      sgroup "PBS_CORE_RAM_CFG1 (at 0x70a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_NVM_CFG1"
      sgroup "PBS_CORE_NVM_CFG1 (at 0x70a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SIZE                                     = "
    tree.end
    tree "PBS_CORE_NVM_CFG2"
      sgroup "PBS_CORE_NVM_CFG2 (at 0x70a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPE                                     = " "0 (OTP),1 (ROM)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ACCESS                                   = " "0 (WRITE_1200US_READ_800NS_INSTR_PR_1510NS),1 (WRITE_600US_READ_400NS_INSTR_PR_940NS),2 (WRITE_300US_READ_200NS_INSTR_PR_730NS),3 (reserved)"
    tree.end
    tree "PBS_CORE_NUM_MACHINE_REGS"
      sgroup "PBS_CORE_NUM_MACHINE_REGS (at 0x70a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   NUM_MACHINE_REGS                         = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEBUG_DTEST                              = " "0 (DEBUG_NEXT_CMD),1 (DEBUG_NEXT_DTEST)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0 (DEBUG_NEXT_NOP),1 (DEBUG_NEXT_TRIGGER)"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_DTEST"
      sgroup "PBS_CORE_SEQ_DEBUG_DTEST (at 0x70e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBUG_DTEST_SEL                          = " "0 (DTEST1),1 (DTEST2),2 (DTEST3),3 (DTEST4),4 (DTEST5),5 (DTEST6),6 (DTEST7),7 (DTEST8)"
    tree.end
  tree.end
tree.end
tree "PFIFO"
  tree "PFIFO"
    tree "PFIFO_REVISION1"
      sgroup "PFIFO_REVISION1 (at 0x3d00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PFIFO_REVISION2"
      sgroup "PFIFO_REVISION2 (at 0x3d01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PFIFO_PERPH_TYPE"
      sgroup "PFIFO_PERPH_TYPE (at 0x3d04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PFIFO_PERPH_SUBTYPE"
      sgroup "PFIFO_PERPH_SUBTYPE (at 0x3d05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PFIFO_STAT_0"
      sgroup "PFIFO_STAT_0 (at 0x3d08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FILL_0                                   = "
    tree.end
    tree "PFIFO_STAT_1"
      sgroup "PFIFO_STAT_1 (at 0x3d09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FILL_1                                   = "
    tree.end
    tree "PFIFO_STAT_2"
      sgroup "PFIFO_STAT_2 (at 0x3d0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EMPTY                                    = " "0 (NOT_EMPTY),1 (IS_EMPTY)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FULL                                     = " "0 (NOT_FULL),1 (IS_FULL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UFLOW                                    = " "0 (NOT_UNDERFLOW),1 (UNDERFLOW_DETECTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OFLOW                                    = " "0 (NOT_OVERFLOW),1 (OVERFLOW_DETECTED)"
    tree.end
    tree "PFIFO_PFIFO_SIZE"
      sgroup "PFIFO_PFIFO_SIZE (at 0x3d0b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFIFO_SIZE                               = " "0 (PFIFO_128X32),1 (PFIFO_256X32),2 (PFIFO_512X32),3 (reserved)"
    tree.end
    tree "PFIFO_INT_RT_STS"
      sgroup "PFIFO_INT_RT_STS (at 0x3d10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_RT_STS                         = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_RT_STS                     = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PFIFO_INT_SET_TYPE"
      sgroup "PFIFO_INT_SET_TYPE (at 0x3d11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_TYPE                           = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_TYPE                       = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PFIFO_INT_POLARITY_HIGH"
      sgroup "PFIFO_INT_POLARITY_HIGH (at 0x3d12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_HIGH                           = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_HIGH                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PFIFO_INT_POLARITY_LOW"
      sgroup "PFIFO_INT_POLARITY_LOW (at 0x3d13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_LOW                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_LOW                        = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PFIFO_INT_LATCHED_CLR"
      sgroup "PFIFO_INT_LATCHED_CLR (at 0x3d14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_LATCHED_CLR                    = " "0 (DONT_CLR),1 (CLR_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_LATCHED_CLR                = " "0 (DONT_CLR),1 (CLR_LATCHED)"
    tree.end
    tree "PFIFO_INT_EN_SET"
      sgroup "PFIFO_INT_EN_SET (at 0x3d15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_EN_SET                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_EN_SET                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PFIFO_INT_EN_CLR"
      sgroup "PFIFO_INT_EN_CLR (at 0x3d16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_EN_CLR                         = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_EN_CLR                     = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PFIFO_INT_LATCHED_STS"
      sgroup "PFIFO_INT_LATCHED_STS (at 0x3d18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_LATCHED_STS                    = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_LATCHED_STS                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "PFIFO_INT_PENDING_STS"
      sgroup "PFIFO_INT_PENDING_STS (at 0x3d19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_PENDING_STS                    = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_PENDING_STS                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PFIFO_INT_MID_SEL"
      sgroup "PFIFO_INT_MID_SEL (at 0x3d1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PFIFO_INT_PRIORITY"
      sgroup "PFIFO_INT_PRIORITY (at 0x3d1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PFIFO_DATA_0"
      sgroup "PFIFO_DATA_0 (at 0x3d60)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_0                                   = "
    tree.end
    tree "PFIFO_DATA_1"
      sgroup "PFIFO_DATA_1 (at 0x3d61)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_1                                   = "
    tree.end
    tree "PFIFO_DATA_2"
      sgroup "PFIFO_DATA_2 (at 0x3d62)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_2                                   = "
    tree.end
    tree "PFIFO_DATA_3"
      sgroup "PFIFO_DATA_3 (at 0x3d63)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_3                                   = "
    tree.end
    tree "PFIFO_DATA_4"
      sgroup "PFIFO_DATA_4 (at 0x3d64)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_4                                   = "
    tree.end
    tree "PFIFO_DATA_5"
      sgroup "PFIFO_DATA_5 (at 0x3d65)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_5                                   = "
    tree.end
    tree "PFIFO_DATA_6"
      sgroup "PFIFO_DATA_6 (at 0x3d66)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_6                                   = "
    tree.end
    tree "PFIFO_DATA_7"
      sgroup "PFIFO_DATA_7 (at 0x3d67)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7                                   = "
    tree.end
    tree "PFIFO_CTRL_1"
      sgroup "PFIFO_CTRL_1 (at 0x3d6b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLRERR                                   = " "0 (DONT_CLR_ERROR),1 (CLR_ERROR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET                                    = " "0 (DONT_RESET),1 (DO_RESET)"
    tree.end
    tree "PFIFO_THRS_0"
      sgroup "PFIFO_THRS_0 (at 0x3d6c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d6c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   THRS_0                                   = "
    tree.end
    tree "PFIFO_THRS_1"
      sgroup "PFIFO_THRS_1 (at 0x3d6d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d6d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   THRS_1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PFIFO_WRAP"
      sgroup "PFIFO_WRAP (at 0x3d6f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d6f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d6f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WRAP                                     = " "0 (NO_WRAP_MODE),1 (WRAP_MODE)"
    tree.end
    tree "PFIFO_WRPTRLO"
      sgroup "PFIFO_WRPTRLO (at 0x3d70)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   WRPTRLO                                  = "
    tree.end
    tree "PFIFO_WRPTRHI"
      sgroup "PFIFO_WRPTRHI (at 0x3d71)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WRPTRHI                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PFIFO_RDPTRLO"
      sgroup "PFIFO_RDPTRLO (at 0x3d72)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RDPTRLO                                  = "
    tree.end
    tree "PFIFO_RDPTRHI"
      sgroup "PFIFO_RDPTRHI (at 0x3d73)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RDPTRHI                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PFIFO_HEAD"
      sgroup "PFIFO_HEAD (at 0x3d74)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   WRHEAD                                   = "
    tree.end
    tree "PFIFO_TAIL"
      sgroup "PFIFO_TAIL (at 0x3d75)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803d750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3d750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RDHEAD                                   = "
    tree.end
    tree "PFIFO_SEC_ACCESS"
      sgroup "PFIFO_SEC_ACCESS (at 0x3dd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PFIFO_PERPH_RESET_CTL2"
      sgroup "PFIFO_PERPH_RESET_CTL2 (at 0x3dd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PFIFO_PERPH_RESET_CTL3"
      sgroup "PFIFO_PERPH_RESET_CTL3 (at 0x3dda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PFIFO_PERPH_RESET_CTL4"
      sgroup "PFIFO_PERPH_RESET_CTL4 (at 0x3ddb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PFIFO_INT_TEST1"
      sgroup "PFIFO_INT_TEST1 (at 0x3de0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "PFIFO_INT_TEST_VAL"
      sgroup "PFIFO_INT_TEST_VAL (at 0x3de1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AFULL_INT_TEST_VAL                       = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFIFO_ERR_INT_TEST_VAL                   = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "PFIFO_TEST1"
      sgroup "PFIFO_TEST1 (at 0x3de2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        set &access:&cmd_addr %l 0x803de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0 (NO_RESET),1 (RESET_OCCURRED)"
    tree.end
    tree "PON_FSM_STATUS"
      sgroup "PON_FSM_STATUS (at 0x808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FSM_STATE                                = " "0 (OFF),1 (PON),2 (POFF),3 (ON),4 (DVDD_CONFIG),5 (RESERVED),6 (FAULT),7 (WARM_RESET)"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LEVEL),1 (EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_RECEIVED),1 (INTERRUPT_RECEIVED)"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL2"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL2 (at 0x843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL2"
      sgroup "PON_RESIN_N_RESET_S2_CTL2 (at 0x847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL2 (at 0x84b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S2_CTL2"
      sgroup "PON_GP2_RESET_S2_CTL2 (at 0x84f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0 (MS_0),1 (MS_10),2 (MS_50),3 (MS_100),4 (MS_250),5 (MS_500),6 (S_1),7 (S_2)"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S2_CTL2"
      sgroup "PON_GP1_RESET_S2_CTL2 (at 0x853)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL2"
      sgroup "PON_PMIC_WD_RESET_S2_CTL2 (at 0x857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x858)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0 (NOP_WD),1 (PET_WD)"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PS_HOLD_RESET_CTL2"
      sgroup "PON_PS_HOLD_RESET_CTL2 (at 0x85b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL2"
      sgroup "PON_SW_RESET_S2_CTL2 (at 0x863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAULT_N_PU_EN                            = " "0 (PU_DISABLED),1 (PU_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0 (PD_DISABLED),1 (PD_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0 (PU_DISABLED),1 (PU_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0 (PU_DISABLED),1 (PU_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0 (PU_DISABLED),1 (PU_ENABLED)"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DEBOUNCE                                 = "
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0 (KPDPWR_N),1 (RESIN_N),2 (KPDPWR_AND_RESIN),3 (KPDPWR_OR_RESIN)"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0 (IMMEDIATE),1 (SEC_2),2 (SEC_4),3 (SEC_8),4 (SEC_16),5 (SEC_32),6 (SEC_64),7 (SEC_128)"
    tree.end
    tree "PON_SMPL_CTL"
      sgroup "PON_SMPL_CTL (at 0x87f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80087f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x87f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SMPL_EN                                  = " "0 (SMPL_DISABLE),1 (SMPL_ENABLED)"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (DISABLED),1 (ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_PON_TRIGGER_EDGE_CONFIG"
      sgroup "PON_PON_TRIGGER_EDGE_CONFIG (at 0x881)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CBLPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB_CHG_REDGE_PON                        = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DC_CHG_REDGE_PON                         = " "0 (LEVEL),1 (REDGE)"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PON1_REDGE_PON                           = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CBLPWR_FEDGE_PON                         = " "0 (LEVEL),1 (FEDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB_CHG_REDGE_PON                        = " "0 (LEVEL),1 (REDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DC_CHG_REDGE_PON                         = " "0 (LEVEL),1 (REDGE)"
    tree.end
    tree "PON_UVLO_CTL"
      sgroup "PON_UVLO_CTL (at 0x884)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_EN                                  = " "0 (UVLO_DISABLED),1 (UVLO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   UVLO_HYST                                = " "0 (MV_150),1 (MV_300),2 (MV_450),3 (MV_600)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   UVLO_THRESH                              = "
    tree.end
    tree "PON_UVLO_RB_STATUS"
      sgroup "PON_UVLO_RB_STATUS (at 0x885)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_RB                                  = " "0 (DEASSERTED),1 (ASSERTED)"
    tree.end
    tree "PON_OVLO_CTL"
      sgroup "PON_OVLO_CTL (at 0x886)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVLO_EN                                  = " "0 (OVLO_DISABLED),1 (OVLO_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   OVLO_HYST                                = " "0 (MV_250),1 (MV_500),2 (MV_1000),3 (MV_2000)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   OVLO_THRESH                              = "
    tree.end
    tree "PON_OVLO_RB_STATUS"
      sgroup "PON_OVLO_RB_STATUS (at 0x887)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVLO_RB                                  = " "0 (DEASSERTED),1 (ASSERTED)"
    tree.end
    tree "PON_XVLO"
      sgroup "PON_XVLO (at 0x888)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   XVLO_DLY                                 = " "0 (IMMEDIATE),1 (MSEC_0P98),2 (MSEC_1P95),3 (MSEC_3P91),4 (MSEC_7P81),5 (MSEC_15P63),6 (MSEC_31P25),7 (MSEC_62P5)"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0 (NACK),1 (ACK)"
    tree.end
    tree "PON_PBS_WDOG_PET"
      sgroup "PON_PBS_WDOG_PET (at 0x892)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PBS_WATCHDOG_PET                         = " "0 (NOP),1 (PET)"
    tree.end
    tree "PON_DEBUG_CTL"
      sgroup "PON_DEBUG_CTL (at 0x894)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DEBUG_CLOCK                              = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEBUG_CLOCK_SRC                          = " "0 (RESIN_N),1 (CLK_32K_AON)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SEL_DEBUG                                = "
    tree.end
    tree "PON_DEBUG_STATUS"
      sgroup "PON_DEBUG_STATUS (at 0x895)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DEBUG_STATE                              = "
    tree.end
    tree "PON_RESET_CTL"
      sgroup "PON_RESET_CTL (at 0x898)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WARM_RB                                  = " "0 (ASSERTED),1 (DEASSERTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SHUTDOWN1_RB                             = " "0 (ASSERTED),1 (DEASSERTED)"
    tree.end
    tree "PON_PON_RESET_N_CTL"
      sgroup "PON_PON_RESET_N_CTL (at 0x899)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_RESET_N                              = " "0 (ASSERTED),1 (DEASSERTED)"
    tree.end
    tree "PON_PS_HOLD_STATUS"
      sgroup "PON_PS_HOLD_STATUS (at 0x89a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80089a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x89a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_HOLD                                  = " "0 (ASSERTED),1 (DEASSERTED)"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x8c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x8c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_ON_REASON"
      sgroup "PON_ON_REASON (at 0x8c4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_SEQ                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WARM_SEQ                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x8c5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_OFF_REASON"
      sgroup "PON_OFF_REASON (at 0x8c7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   POFF_SEQ                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FAULT_SEQ                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   S3_RESET                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IMMEDIATE_XVDD_SHUTDOWN                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAW_DVDD_RB_OCCURED                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RAW_XVDD_RB_OCCURED                      = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_FAULT_REASON1"
      sgroup "PON_FAULT_REASON1 (at 0x8c8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_RB                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OVLO                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MBG_FAULT                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP_FAULT3                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GP_FAULT2                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GP_FAULT1                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GP_FAULT0                                = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_FAULT_REASON2"
      sgroup "PON_FAULT_REASON2 (at 0x8c9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008c90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8c90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OTST3                                    = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESTART_PON                              = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PBS_NACK                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PBS_WATCHDOG_TO                          = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FAULT_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_S3_RESET_REASON"
      sgroup "PON_S3_RESET_REASON (at 0x8ca)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008ca0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8ca0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_ANDOR_RESIN                       = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PBS_NACK                                 = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PBS_WATCHDOG_TO                          = " "0 (reserved),1 (TRIGGER_RECEIVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAULT_N                                  = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x8cb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008cb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8cb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0 (reserved),1 (TRIGGER_RECEIVED)"
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_RESET_OCCURED                       = " "0 (SOFT_RESET_OCCURED_TEST_FALSE),1 (SOFT_RESET_OCCURED_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0 (PMIC_WD_BARK_TEST_FALSE),1 (PMIC_WD_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0 (K_R_BARK_TEST_FALSE),1 (K_R_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0 (RESIN_BARK_TEST_FALSE),1 (RESIN_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0 (KPDPWR_BARK_TEST_FALSE),1 (KPDPWR_BARK_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0 (CBLPWR_ON_TEST_FALSE),1 (CBLPWR_ON_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0 (RESIN_ON_TEST_FALSE),1 (RESIN_ON_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0 (KPDPWR_ON_TEST_FALSE),1 (KPDPWR_ON_TEST_TRUE)"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0 (UVLO_TEST_DISABLED),1 (UVLO_TEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVLO_TEST_EN                             = " "0 (OVLO_TEST_DISABLED),1 (OVLO_TEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0 (FORCE_ON_DISABLED),1 (FORCE_ON_ENABLED)"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_DEC_SEL                            = " "0, 1"
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3_SEL                               = "
    tree.end
    tree "PON_TEST4"
      sgroup "PON_TEST4 (at 0x8e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1_SEL                               = "
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0 (FOLLOW_DVDD_RB),1 (MASK_DVDD_RB)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0 (FOLLOW_SHUTDOWN1_RB),1 (MASK_SHUTDOWN1_RB)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0 (FOLLOW_SHUTDOWN2_RB),1 (MASK_SHUTDOWN2_RB)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0 (FOLLOW_WARM_RB),1 (MASK_WARM_RB)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0 (FOLLOW_GLOBAL_SOFT_RB),1 (MASK_GLOBAL_SOFT_RB)"
    tree.end
    tree "PON_REG_WRITE_STATUS"
      sgroup "PON_REG_WRITE_STATUS (at 0x8ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WR_RDY                                   = " "0 (WR_WIP),1 (WR_RDY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WR_ILG                                   = " "0 (WR_OK),1 (WR_ILG)"
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
  tree.end
tree.end
tree "PWM1"
  tree "PWM1"
    tree "PWM1_REVISION1"
      sgroup "PWM1_REVISION1 (at 0x1bc00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PWM1_REVISION2"
      sgroup "PWM1_REVISION2 (at 0x1bc01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PWM1_PERPH_TYPE"
      sgroup "PWM1_PERPH_TYPE (at 0x1bc04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PWM1_PERPH_SUBTYPE"
      sgroup "PWM1_PERPH_SUBTYPE (at 0x1bc05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PWM1_PWM_SIZE_CLK"
      sgroup "PWM1_PWM_SIZE_CLK (at 0x1bc41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "PWM1_PWM_FREQ_PREDIV_CLK"
      sgroup "PWM1_PWM_FREQ_PREDIV_CLK (at 0x1bc42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "PWM1_PWM_TYPE_CONFIG"
      sgroup "PWM1_PWM_TYPE_CONFIG (at 0x1bc43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "PWM1_PWM_VALUE_LSB"
      sgroup "PWM1_PWM_VALUE_LSB (at 0x1bc44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "PWM1_PWM_VALUE_MSB"
      sgroup "PWM1_PWM_VALUE_MSB (at 0x1bc45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "PWM1_ENABLE_CONTROL"
      sgroup "PWM1_ENABLE_CONTROL (at 0x1bc46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0 (PWM_DISABLE),1 (PWM_ENABLE)"
    tree.end
    tree "PWM1_PWM_SYNC"
      sgroup "PWM1_PWM_SYNC (at 0x1bc47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bc470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbc470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0, 1"
    tree.end
    tree "PWM1_SEC_ACCESS"
      sgroup "PWM1_SEC_ACCESS (at 0x1bcd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PWM1_PERPH_RESET_CTL1"
      sgroup "PWM1_PERPH_RESET_CTL1 (at 0x1bcd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PWM1_PERPH_RESET_CTL2"
      sgroup "PWM1_PERPH_RESET_CTL2 (at 0x1bcd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM1_PERPH_RESET_CTL3"
      sgroup "PWM1_PERPH_RESET_CTL3 (at 0x1bcda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM1_PERPH_RESET_CTL4"
      sgroup "PWM1_PERPH_RESET_CTL4 (at 0x1bcdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bcdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbcdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PWM1_TEST1"
      sgroup "PWM1_TEST1 (at 0x1bce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (PWM_OUT),2 (reserved),3 (reserved)"
    tree.end
    tree "PWM1_TEST2"
      sgroup "PWM1_TEST2 (at 0x1bce3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (reserved),2 (PWM_OUT),3 (reserved)"
    tree.end
    tree "PWM1_TEST3"
      sgroup "PWM1_TEST3 (at 0x1bce4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        set &access:&cmd_addr %l 0x80bce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_GEN_BYPASS                           = " "0 (BYPASS_DISABLE),1 (BYPASS_ENABLE)"
    tree.end
  tree.end
tree.end
tree "PWM2"
  tree "PWM2"
    tree "PWM2_REVISION1"
      sgroup "PWM2_REVISION1 (at 0x1bd00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PWM2_REVISION2"
      sgroup "PWM2_REVISION2 (at 0x1bd01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PWM2_PERPH_TYPE"
      sgroup "PWM2_PERPH_TYPE (at 0x1bd04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PWM2_PERPH_SUBTYPE"
      sgroup "PWM2_PERPH_SUBTYPE (at 0x1bd05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PWM2_PWM_SIZE_CLK"
      sgroup "PWM2_PWM_SIZE_CLK (at 0x1bd41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_SIZE                                 = " "0 (PWM_6BIT),1 (PWM_9BIT)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PWM_FREQ_CLK_SELECT                      = " "0 (NOCLK),1 (CLK_1KHZ),2 (CLK_32KHZ),3 (CLK_19P2MHZ)"
    tree.end
    tree "PWM2_PWM_FREQ_PREDIV_CLK"
      sgroup "PWM2_PWM_FREQ_PREDIV_CLK (at 0x1bd42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   PWM_FREQ_PRE_DIVIDE                      = " "0 (PREDIV_ONE),1 (PREDIV_THREE),2 (PREDIV_FIVE),3 (PREDIV_SIX)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_FREQ_EXPONENT                        = " "0 (EXP_ZERO),1 (EXP_ONE),2 (EXP_TWO),3 (EXP_THREE),4 (EXP_FOUR),5 (EXP_FIVE),6 (EXP_SIX),7 (EXP_SEVEN)"
    tree.end
    tree "PWM2_PWM_TYPE_CONFIG"
      sgroup "PWM2_PWM_TYPE_CONFIG (at 0x1bd43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_GLITCH_REMOVAL                        = " "0 (GLITCH_REMOVE_DIS),1 (GLITCH_REMOVE_EN)"
    tree.end
    tree "PWM2_PWM_VALUE_LSB"
      sgroup "PWM2_PWM_VALUE_LSB (at 0x1bd44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_VALUE_LSB                            = "
    tree.end
    tree "PWM2_PWM_VALUE_MSB"
      sgroup "PWM2_PWM_VALUE_MSB (at 0x1bd45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PWM_VALUE_MSB                            = " "0, 1"
    tree.end
    tree "PWM2_ENABLE_CONTROL"
      sgroup "PWM2_ENABLE_CONTROL (at 0x1bd46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MODULE                                = " "0 (PWM_DISABLE),1 (PWM_ENABLE)"
    tree.end
    tree "PWM2_PWM_SYNC"
      sgroup "PWM2_PWM_SYNC (at 0x1bd47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bd470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SYNC_PWM                                 = " "0, 1"
    tree.end
    tree "PWM2_SEC_ACCESS"
      sgroup "PWM2_SEC_ACCESS (at 0x1bdd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bdd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbdd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PWM2_PERPH_RESET_CTL1"
      sgroup "PWM2_PERPH_RESET_CTL1 (at 0x1bdd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bdd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbdd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PWM2_PERPH_RESET_CTL2"
      sgroup "PWM2_PERPH_RESET_CTL2 (at 0x1bdd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bdd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbdd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM2_PERPH_RESET_CTL3"
      sgroup "PWM2_PERPH_RESET_CTL3 (at 0x1bdda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bdda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbdda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "PWM2_PERPH_RESET_CTL4"
      sgroup "PWM2_PERPH_RESET_CTL4 (at 0x1bddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "PWM2_TEST1"
      sgroup "PWM2_TEST1 (at 0x1bde2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bde20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbde20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST1                                   = " "0 (TEST_DIS),1 (PWM_OUT),2 (reserved),3 (reserved)"
    tree.end
    tree "PWM2_TEST2"
      sgroup "PWM2_TEST2 (at 0x1bde3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bde30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbde30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST2                                   = " "0 (TEST_DIS),1 (reserved),2 (PWM_OUT),3 (reserved)"
    tree.end
    tree "PWM2_TEST3"
      sgroup "PWM2_TEST3 (at 0x1bde4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        set &access:&cmd_addr %l 0x80bde40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xbd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbde40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_GEN_BYPASS                           = " "0 (BYPASS_DISABLE),1 (BYPASS_ENABLE)"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_SBL_ID_0"
      sgroup "REVID_SBL_ID_0 (at 0x150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_SBL_ID_1"
      sgroup "REVID_SBL_ID_1 (at 0x151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_REVID_SPARE_0"
      sgroup "REVID_REVID_SPARE_0 (at 0x160)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID_REVID_SPARE_1"
      sgroup "REVID_REVID_SPARE_1 (at 0x161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
  tree.end
tree.end
tree "REVID1"
  tree "REVID1"
    tree "REVID1_REVISION1"
      sgroup "REVID1_REVISION1 (at 0x10100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID1_REVISION2"
      sgroup "REVID1_REVISION2 (at 0x10101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID1_REVISION3"
      sgroup "REVID1_REVISION3 (at 0x10102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID1_REVISION4"
      sgroup "REVID1_REVISION4 (at 0x10103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID1_PERPH_TYPE"
      sgroup "REVID1_PERPH_TYPE (at 0x10104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID1_PERPH_SUBTYPE"
      sgroup "REVID1_PERPH_SUBTYPE (at 0x10105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID1_SBL_ID_0"
      sgroup "REVID1_SBL_ID_0 (at 0x10150)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID1_SBL_ID_1"
      sgroup "REVID1_SBL_ID_1 (at 0x10151)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID1_REVID_SPARE_0"
      sgroup "REVID1_REVID_SPARE_0 (at 0x10160)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID1_REVID_SPARE_1"
      sgroup "REVID1_REVID_SPARE_1 (at 0x10161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
  tree.end
tree.end
tree "RF_CLK1"
  tree "RF_CLK1"
    tree "RF_CLK1_REVISION1"
      sgroup "RF_CLK1_REVISION1 (at 0x5400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION2"
      sgroup "RF_CLK1_REVISION2 (at 0x5401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK1_REVISION3"
      sgroup "RF_CLK1_REVISION3 (at 0x5402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK1_REVISION4"
      sgroup "RF_CLK1_REVISION4 (at 0x5403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK1_PERPH_TYPE"
      sgroup "RF_CLK1_PERPH_TYPE (at 0x5404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK1_PERPH_SUBTYPE"
      sgroup "RF_CLK1_PERPH_SUBTYPE (at 0x5405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK1_STATUS1"
      sgroup "RF_CLK1_STATUS1 (at 0x5408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLK_ENA_HOLD                             = " "0 (RFCLK_UNLATCH),1 (RFCLK_LATCH)"
    tree.end
    tree "RF_CLK1_EDGE_CTL1"
      sgroup "RF_CLK1_EDGE_CTL1 (at 0x5443)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_EDGE                                 = " "0, 1, 2, 3"
    tree.end
    tree "RF_CLK1_DRV_CTL1"
      sgroup "RF_CLK1_DRV_CTL1 (at 0x5444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK1_CLKBUFF_HOLD_CTL"
      sgroup "RF_CLK1_CLKBUFF_HOLD_CTL (at 0x5445)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLKBUFF_HOLD                             = "
    tree.end
    tree "RF_CLK1_EN_CTL"
      sgroup "RF_CLK1_EN_CTL (at 0x5446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK1_CLK_EN_CTL"
      sgroup "RF_CLK1_CLK_EN_CTL (at 0x5447)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK1_PD_CTL"
      sgroup "RF_CLK1_PD_CTL (at 0x5448)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK1_TIMER"
      sgroup "RF_CLK1_TIMER (at 0x544c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x80544c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x544c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DELAY                                    = "
    tree.end
    tree "RF_CLK1_SEC_ACCESS"
      sgroup "RF_CLK1_SEC_ACCESS (at 0x54d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL1"
      sgroup "RF_CLK1_PERPH_RESET_CTL1 (at 0x54d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL2"
      sgroup "RF_CLK1_PERPH_RESET_CTL2 (at 0x54d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL3"
      sgroup "RF_CLK1_PERPH_RESET_CTL3 (at 0x54da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK1_PERPH_RESET_CTL4"
      sgroup "RF_CLK1_PERPH_RESET_CTL4 (at 0x54db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RF_CLK1_TEST1"
      sgroup "RF_CLK1_TEST1 (at 0x54e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TEST_EN                          = " "0 (CLKBUFF_DISA),1 (CLKBUFF_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_EN                                 = " "0 (ATEST_HI_Z),1 (CLK_DC_DFT)"
    tree.end
    tree "RF_CLK1_TEST2"
      sgroup "RF_CLK1_TEST2 (at 0x54e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OUTBUFF_TIMING                           = " "0 (SINGLE_CLK),1 (DOUBLE_CLK)"
    tree.end
    tree "RF_CLK1_TEST3"
      sgroup "RF_CLK1_TEST3 (at 0x54e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        set &access:&cmd_addr %l 0x8054e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x54e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TO_DTEST                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLKBUFF_DRIVE_EN                         = " "0 (DISABLE),1 (ENABLE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK2"
  tree "RF_CLK2"
    tree "RF_CLK2_REVISION1"
      sgroup "RF_CLK2_REVISION1 (at 0x5500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION2"
      sgroup "RF_CLK2_REVISION2 (at 0x5501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK2_REVISION3"
      sgroup "RF_CLK2_REVISION3 (at 0x5502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK2_REVISION4"
      sgroup "RF_CLK2_REVISION4 (at 0x5503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK2_PERPH_TYPE"
      sgroup "RF_CLK2_PERPH_TYPE (at 0x5504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK2_PERPH_SUBTYPE"
      sgroup "RF_CLK2_PERPH_SUBTYPE (at 0x5505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK2_STATUS1"
      sgroup "RF_CLK2_STATUS1 (at 0x5508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLK_ENA_HOLD                             = " "0 (RFCLK_UNLATCH),1 (RFCLK_LATCH)"
    tree.end
    tree "RF_CLK2_EDGE_CTL1"
      sgroup "RF_CLK2_EDGE_CTL1 (at 0x5543)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_EDGE                                 = " "0, 1, 2, 3"
    tree.end
    tree "RF_CLK2_DRV_CTL1"
      sgroup "RF_CLK2_DRV_CTL1 (at 0x5544)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK2_CLKBUFF_HOLD_CTL"
      sgroup "RF_CLK2_CLKBUFF_HOLD_CTL (at 0x5545)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLKBUFF_HOLD                             = "
    tree.end
    tree "RF_CLK2_EN_CTL"
      sgroup "RF_CLK2_EN_CTL (at 0x5546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK2_CLK_EN_CTL"
      sgroup "RF_CLK2_CLK_EN_CTL (at 0x5547)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK2_PD_CTL"
      sgroup "RF_CLK2_PD_CTL (at 0x5548)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK2_TIMER"
      sgroup "RF_CLK2_TIMER (at 0x554c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x80554c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x554c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DELAY                                    = "
    tree.end
    tree "RF_CLK2_SEC_ACCESS"
      sgroup "RF_CLK2_SEC_ACCESS (at 0x55d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL1"
      sgroup "RF_CLK2_PERPH_RESET_CTL1 (at 0x55d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL2"
      sgroup "RF_CLK2_PERPH_RESET_CTL2 (at 0x55d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL3"
      sgroup "RF_CLK2_PERPH_RESET_CTL3 (at 0x55da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK2_PERPH_RESET_CTL4"
      sgroup "RF_CLK2_PERPH_RESET_CTL4 (at 0x55db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RF_CLK2_TEST1"
      sgroup "RF_CLK2_TEST1 (at 0x55e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TEST_EN                          = " "0 (CLKBUFF_DISA),1 (CLKBUFF_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_EN                                 = " "0 (ATEST_HI_Z),1 (CLK_DC_DFT)"
    tree.end
    tree "RF_CLK2_TEST2"
      sgroup "RF_CLK2_TEST2 (at 0x55e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OUTBUFF_TIMING                           = " "0 (SINGLE_CLK),1 (DOUBLE_CLK)"
    tree.end
    tree "RF_CLK2_TEST3"
      sgroup "RF_CLK2_TEST3 (at 0x55e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        set &access:&cmd_addr %l 0x8055e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x55e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TO_DTEST                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLKBUFF_DRIVE_EN                         = " "0 (DISABLE),1 (ENABLE)"
    tree.end
  tree.end
tree.end
tree "RF_CLK3"
  tree "RF_CLK3"
    tree "RF_CLK3_REVISION1"
      sgroup "RF_CLK3_REVISION1 (at 0x5600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RF_CLK3_REVISION2"
      sgroup "RF_CLK3_REVISION2 (at 0x5601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RF_CLK3_REVISION3"
      sgroup "RF_CLK3_REVISION3 (at 0x5602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "RF_CLK3_REVISION4"
      sgroup "RF_CLK3_REVISION4 (at 0x5603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "RF_CLK3_PERPH_TYPE"
      sgroup "RF_CLK3_PERPH_TYPE (at 0x5604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RF_CLK3_PERPH_SUBTYPE"
      sgroup "RF_CLK3_PERPH_SUBTYPE (at 0x5605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RF_CLK3_STATUS1"
      sgroup "RF_CLK3_STATUS1 (at 0x5608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_OK                                   = " "0 (RFCLK_OFF),1 (RFCLK_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLK_ENA_HOLD                             = " "0 (RFCLK_UNLATCH),1 (RFCLK_LATCH)"
    tree.end
    tree "RF_CLK3_EDGE_CTL1"
      sgroup "RF_CLK3_EDGE_CTL1 (at 0x5643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_EDGE                                 = " "0, 1, 2, 3"
    tree.end
    tree "RF_CLK3_DRV_CTL1"
      sgroup "RF_CLK3_DRV_CTL1 (at 0x5644)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "RF_CLK3_CLKBUFF_HOLD_CTL"
      sgroup "RF_CLK3_CLKBUFF_HOLD_CTL (at 0x5645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLKBUFF_HOLD                             = "
    tree.end
    tree "RF_CLK3_EN_CTL"
      sgroup "RF_CLK3_EN_CTL (at 0x5646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CLK_EN                                   = " "0 (RFCLK_NOT_FORCE),1 (RFCLK_FORCE_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PC_POLARITY                              = " "0 (POS_PINCONTROL_POLARITY),1 (NEG_PINCONTROL_POLARITY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK3_CLK_EN_CTL"
      sgroup "RF_CLK3_CLK_EN_CTL (at 0x5647)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_PC_EN                             = " "0 (NOT_FOLLOW_PIN),1 (FOLLOW_PIN)"
    tree.end
    tree "RF_CLK3_PD_CTL"
      sgroup "RF_CLK3_PD_CTL (at 0x5648)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0 (PULLDN_DIS),1 (PULLDN_EN)"
    tree.end
    tree "RF_CLK3_TIMER"
      sgroup "RF_CLK3_TIMER (at 0x564c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x80564c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x564c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DELAY                                    = "
    tree.end
    tree "RF_CLK3_SEC_ACCESS"
      sgroup "RF_CLK3_SEC_ACCESS (at 0x56d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL1"
      sgroup "RF_CLK3_PERPH_RESET_CTL1 (at 0x56d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL2"
      sgroup "RF_CLK3_PERPH_RESET_CTL2 (at 0x56d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL3"
      sgroup "RF_CLK3_PERPH_RESET_CTL3 (at 0x56da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RF_CLK3_PERPH_RESET_CTL4"
      sgroup "RF_CLK3_PERPH_RESET_CTL4 (at 0x56db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RF_CLK3_TEST1"
      sgroup "RF_CLK3_TEST1 (at 0x56e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TEST_EN                          = " "0 (CLKBUFF_DISA),1 (CLKBUFF_ENA)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ATEST_EN                                 = " "0 (ATEST_HI_Z),1 (CLK_DC_DFT)"
    tree.end
    tree "RF_CLK3_TEST2"
      sgroup "RF_CLK3_TEST2 (at 0x56e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OUTBUFF_TIMING                           = " "0 (SINGLE_CLK),1 (DOUBLE_CLK)"
    tree.end
    tree "RF_CLK3_TEST3"
      sgroup "RF_CLK3_TEST3 (at 0x56e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        set &access:&cmd_addr %l 0x8056e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x56e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLKBUFF_TO_DTEST                         = " "0 (DISABLE),1 (ENABLE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLKBUFF_DRIVE_EN                         = " "0 (DISABLE),1 (ENABLE)"
    tree.end
  tree.end
tree.end
tree "RTC_ALARM"
  tree "RTC_ALARM"
    tree "RTC_ALARM_REVISION1"
      sgroup "RTC_ALARM_REVISION1 (at 0x6100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_ALARM_REVISION2"
      sgroup "RTC_ALARM_REVISION2 (at 0x6101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_ALARM_PERPH_TYPE"
      sgroup "RTC_ALARM_PERPH_TYPE (at 0x6104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_ALARM_PERPH_SUBTYPE"
      sgroup "RTC_ALARM_PERPH_SUBTYPE (at 0x6105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_ALARM_STATUS1"
      sgroup "RTC_ALARM_STATUS1 (at 0x6108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_ALARM_OK                             = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
    tree.end
    tree "RTC_ALARM_INT_RT_STS"
      sgroup "RTC_ALARM_INT_RT_STS (at 0x6110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (RTC_ALARM_NOT_EXPIRED),1 (RTC_ALARM_EXPIRED)"
    tree.end
    tree "RTC_ALARM_INT_SET_TYPE"
      sgroup "RTC_ALARM_INT_SET_TYPE (at 0x6111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_HIGH"
      sgroup "RTC_ALARM_INT_POLARITY_HIGH (at 0x6112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_POLARITY_LOW"
      sgroup "RTC_ALARM_INT_POLARITY_LOW (at 0x6113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_CLR"
      sgroup "RTC_ALARM_INT_LATCHED_CLR (at 0x6114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_EN_SET"
      sgroup "RTC_ALARM_INT_EN_SET (at 0x6115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_ALARM_INT_EN_CLR"
      sgroup "RTC_ALARM_INT_EN_CLR (at 0x6116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_INT_LATCHED_STS"
      sgroup "RTC_ALARM_INT_LATCHED_STS (at 0x6118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_ALARM_INT_PENDING_STS"
      sgroup "RTC_ALARM_INT_PENDING_STS (at 0x6119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM                                = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_ALARM_INT_MID_SEL"
      sgroup "RTC_ALARM_INT_MID_SEL (at 0x611a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x80611a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x611a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_ALARM_INT_PRIORITY"
      sgroup "RTC_ALARM_INT_PRIORITY (at 0x611b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x80611b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x611b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_ALARM_ALARM_DATA0"
      sgroup "RTC_ALARM_ALARM_DATA0 (at 0x6140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA0                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA1"
      sgroup "RTC_ALARM_ALARM_DATA1 (at 0x6141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA1                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA2"
      sgroup "RTC_ALARM_ALARM_DATA2 (at 0x6142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA2                          = "
    tree.end
    tree "RTC_ALARM_ALARM_DATA3"
      sgroup "RTC_ALARM_ALARM_DATA3 (at 0x6143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_ALARM_DATA3                          = "
    tree.end
    tree "RTC_ALARM_EN_CTL1"
      sgroup "RTC_ALARM_EN_CTL1 (at 0x6146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ALARM_EN                                 = " "0 (RTC_ALARM_DIS),1 (RTC_ALARM_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ABORT_EN                                 = " "0 (RTC_STARTUP_DOESNT_ABORT),1 (RTC_STARTUP_ABORT_EN)"
    tree.end
    tree "RTC_ALARM_ALARM_CTL"
      sgroup "RTC_ALARM_ALARM_CTL (at 0x6147)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALARM_CTL                                = " "0 (ALARMED_GREATER),1 (ALARMED_EQUAL)"
    tree.end
    tree "RTC_ALARM_ALARM_CLR"
      sgroup "RTC_ALARM_ALARM_CLR (at 0x6148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALARM_CLR                                = " "0, 1"
    tree.end
    tree "RTC_ALARM_SEC_ACCESS"
      sgroup "RTC_ALARM_SEC_ACCESS (at 0x61d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL1"
      sgroup "RTC_ALARM_PERPH_RESET_CTL1 (at 0x61d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL2"
      sgroup "RTC_ALARM_PERPH_RESET_CTL2 (at 0x61d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL3"
      sgroup "RTC_ALARM_PERPH_RESET_CTL3 (at 0x61da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_ALARM_PERPH_RESET_CTL4"
      sgroup "RTC_ALARM_PERPH_RESET_CTL4 (at 0x61db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RTC_ALARM_INT_TEST1"
      sgroup "RTC_ALARM_INT_TEST1 (at 0x61e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_ALARM_INT_TEST_VAL"
      sgroup "RTC_ALARM_INT_TEST_VAL (at 0x61e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        set &access:&cmd_addr %l 0x8061e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RTC_ALARM_TEST_VAL                       = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "RTC_RW"
  tree "RTC_RW"
    tree "RTC_RW_REVISION1"
      sgroup "RTC_RW_REVISION1 (at 0x6000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_RW_REVISION2"
      sgroup "RTC_RW_REVISION2 (at 0x6001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_RW_PERPH_TYPE"
      sgroup "RTC_RW_PERPH_TYPE (at 0x6004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_RW_PERPH_SUBTYPE"
      sgroup "RTC_RW_PERPH_SUBTYPE (at 0x6005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_RW_STATUS1"
      sgroup "RTC_RW_STATUS1 (at 0x6008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_OK                                   = " "0 (RTC_OFF),1 (RTC_ON)"
    tree.end
    tree "RTC_RW_STATUS2"
      sgroup "RTC_RW_STATUS2 (at 0x6009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_RST                                  = " "0 (RTC_OFF),1 (RTC_ON)"
    tree.end
    tree "RTC_RW_INT_RT_STS"
      sgroup "RTC_RW_INT_RT_STS (at 0x6010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (RTC_1SEC_NOT_EXPIRED),1 (RTC_1SEC_EXPIRED)"
    tree.end
    tree "RTC_RW_INT_SET_TYPE"
      sgroup "RTC_RW_INT_SET_TYPE (at 0x6011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_RW_INT_POLARITY_HIGH"
      sgroup "RTC_RW_INT_POLARITY_HIGH (at 0x6012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_RW_INT_POLARITY_LOW"
      sgroup "RTC_RW_INT_POLARITY_LOW (at 0x6013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_RW_INT_LATCHED_CLR"
      sgroup "RTC_RW_INT_LATCHED_CLR (at 0x6014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_RW_INT_EN_SET"
      sgroup "RTC_RW_INT_EN_SET (at 0x6015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_RW_INT_EN_CLR"
      sgroup "RTC_RW_INT_EN_CLR (at 0x6016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0, 1"
    tree.end
    tree "RTC_RW_INT_LATCHED_STS"
      sgroup "RTC_RW_INT_LATCHED_STS (at 0x6018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_RW_INT_PENDING_STS"
      sgroup "RTC_RW_INT_PENDING_STS (at 0x6019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ                                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_RW_INT_MID_SEL"
      sgroup "RTC_RW_INT_MID_SEL (at 0x601a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80601a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x601a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_RW_INT_PRIORITY"
      sgroup "RTC_RW_INT_PRIORITY (at 0x601b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80601b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x601b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_RW_WDATA0"
      sgroup "RTC_RW_WDATA0 (at 0x6040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA0                               = "
    tree.end
    tree "RTC_RW_WDATA1"
      sgroup "RTC_RW_WDATA1 (at 0x6041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA1                               = "
    tree.end
    tree "RTC_RW_WDATA2"
      sgroup "RTC_RW_WDATA2 (at 0x6042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA2                               = "
    tree.end
    tree "RTC_RW_WDATA3"
      sgroup "RTC_RW_WDATA3 (at 0x6043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_WDATA3                               = "
    tree.end
    tree "RTC_RW_TIME_ADJ"
      sgroup "RTC_RW_TIME_ADJ (at 0x6044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   RTC_TIME_ADJ                             = "
    tree.end
    tree "RTC_RW_EN_CTL1"
      sgroup "RTC_RW_EN_CTL1 (at 0x6046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RTC_EN                                   = " "0 (RTC_COUNTER_DIS),1 (RTC_COUNTER_EN)"
    tree.end
    tree "RTC_RW_RDATA0"
      sgroup "RTC_RW_RDATA0 (at 0x6048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA0                               = "
    tree.end
    tree "RTC_RW_RDATA1"
      sgroup "RTC_RW_RDATA1 (at 0x6049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA1                               = "
    tree.end
    tree "RTC_RW_RDATA2"
      sgroup "RTC_RW_RDATA2 (at 0x604a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA2                               = "
    tree.end
    tree "RTC_RW_RDATA3"
      sgroup "RTC_RW_RDATA3 (at 0x604b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_RDATA3                               = "
    tree.end
    tree "RTC_RW_STORGE0"
      sgroup "RTC_RW_STORGE0 (at 0x604c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_STORGE0                              = "
    tree.end
    tree "RTC_RW_STORGE1"
      sgroup "RTC_RW_STORGE1 (at 0x604d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_STORGE1                              = "
    tree.end
    tree "RTC_RW_STORGE2"
      sgroup "RTC_RW_STORGE2 (at 0x604e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_STORGE2                              = "
    tree.end
    tree "RTC_RW_STORGE3"
      sgroup "RTC_RW_STORGE3 (at 0x604f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x80604f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x604f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RTC_STORGE3                              = "
    tree.end
    tree "RTC_RW_TS_LATCH"
      sgroup "RTC_RW_TS_LATCH (at 0x6050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TS_LATCH                                 = " "0, 1"
    tree.end
    tree "RTC_RW_TSTAMP0"
      sgroup "RTC_RW_TSTAMP0 (at 0x6051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TS0                                      = "
    tree.end
    tree "RTC_RW_TSTAMP1"
      sgroup "RTC_RW_TSTAMP1 (at 0x6052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TS1                                      = "
    tree.end
    tree "RTC_RW_TSTAMP2"
      sgroup "RTC_RW_TSTAMP2 (at 0x6053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TS2                                      = "
    tree.end
    tree "RTC_RW_TSTAMP3"
      sgroup "RTC_RW_TSTAMP3 (at 0x6054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TS3                                      = "
    tree.end
    tree "RTC_RW_SEC_ACCESS"
      sgroup "RTC_RW_SEC_ACCESS (at 0x60d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL1"
      sgroup "RTC_RW_PERPH_RESET_CTL1 (at 0x60d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL2"
      sgroup "RTC_RW_PERPH_RESET_CTL2 (at 0x60d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL3"
      sgroup "RTC_RW_PERPH_RESET_CTL3 (at 0x60da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_RW_PERPH_RESET_CTL4"
      sgroup "RTC_RW_PERPH_RESET_CTL4 (at 0x60db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RTC_RW_INT_TEST1"
      sgroup "RTC_RW_INT_TEST1 (at 0x60e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_RW_INT_TEST_VAL"
      sgroup "RTC_RW_INT_TEST_VAL (at 0x60e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RTC_1HZ_TEST_VAL                         = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
    tree "RTC_RW_TEST1"
      sgroup "RTC_RW_TEST1 (at 0x60e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST1                                   = " "0 (NORMAL),1 (RTC_1HZ_ON_DTEST1)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DIV20CLKSEL                              = " "0 (NORMAL),1 (ALT_SLP_ON_DIV20)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIVSEL                                   = " "0 (DIV16384),1 (DIV20)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BYPASSDIV2                               = " "0 (DIV2),1 (BYPASS_DIV2)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST2                                   = " "0 (NONE),1 (CLK_1HZ),2 (CLK_1HZ_LATCH),3 (LOAD),4 (ABORT_ALARM),5 (ALARM_INT),6 (RTC_ALARM),7 (ALARM_RST_N)"
    tree.end
    tree "RTC_RW_TEST2"
      sgroup "RTC_RW_TEST2 (at 0x60e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        set &access:&cmd_addr %l 0x8060e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TS_ENABLE                                = " "0 (TS_DISABLE),1 (TS_ENABLE)"
    tree.end
  tree.end
tree.end
tree "RTC_TIMER"
  tree "RTC_TIMER"
    tree "RTC_TIMER_REVISION1"
      sgroup "RTC_TIMER_REVISION1 (at 0x6200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "RTC_TIMER_REVISION2"
      sgroup "RTC_TIMER_REVISION2 (at 0x6201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "RTC_TIMER_PERPH_TYPE"
      sgroup "RTC_TIMER_PERPH_TYPE (at 0x6204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "RTC_TIMER_PERPH_SUBTYPE"
      sgroup "RTC_TIMER_PERPH_SUBTYPE (at 0x6205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "RTC_TIMER_STATUS1"
      sgroup "RTC_TIMER_STATUS1 (at 0x6208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_OK                                 = " "0 (TIMER_OFF),1 (TIMER_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_RT_STS"
      sgroup "RTC_TIMER_INT_RT_STS (at 0x6210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (TIMER_NOT_EXPIRED),1 (TIMER_EXPIRED)"
    tree.end
    tree "RTC_TIMER_INT_SET_TYPE"
      sgroup "RTC_TIMER_INT_SET_TYPE (at 0x6211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_HIGH"
      sgroup "RTC_TIMER_INT_POLARITY_HIGH (at 0x6212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_POLARITY_LOW"
      sgroup "RTC_TIMER_INT_POLARITY_LOW (at 0x6213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_CLR"
      sgroup "RTC_TIMER_INT_LATCHED_CLR (at 0x6214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_EN_SET"
      sgroup "RTC_TIMER_INT_EN_SET (at 0x6215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "RTC_TIMER_INT_EN_CLR"
      sgroup "RTC_TIMER_INT_EN_CLR (at 0x6216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0, 1"
    tree.end
    tree "RTC_TIMER_INT_LATCHED_STS"
      sgroup "RTC_TIMER_INT_LATCHED_STS (at 0x6218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "RTC_TIMER_INT_PENDING_STS"
      sgroup "RTC_TIMER_INT_PENDING_STS (at 0x6219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED                            = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "RTC_TIMER_INT_MID_SEL"
      sgroup "RTC_TIMER_INT_MID_SEL (at 0x621a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x80621a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x621a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "RTC_TIMER_INT_PRIORITY"
      sgroup "RTC_TIMER_INT_PRIORITY (at 0x621b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x80621b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x621b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "RTC_TIMER_TIMER_DATA1"
      sgroup "RTC_TIMER_TIMER_DATA1 (at 0x6240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA1                              = "
    tree.end
    tree "RTC_TIMER_TIMER_DATA2"
      sgroup "RTC_TIMER_TIMER_DATA2 (at 0x6242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_DATA2                              = "
    tree.end
    tree "RTC_TIMER_TIMER_MODE"
      sgroup "RTC_TIMER_TIMER_MODE (at 0x6245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONTINUOUS                               = " "0 (TIMER_STOPS),1 (TIMER_RESTARTS)"
    tree.end
    tree "RTC_TIMER_EN_CTL"
      sgroup "RTC_TIMER_EN_CTL (at 0x6246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TIMER_EN                                 = " "0 (TIMER_DIS),1 (TIMER_EN)"
    tree.end
    tree "RTC_TIMER_TIMER_RDATA1"
      sgroup "RTC_TIMER_TIMER_RDATA1 (at 0x6248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA1                             = "
    tree.end
    tree "RTC_TIMER_TIMER_RDATA2"
      sgroup "RTC_TIMER_TIMER_RDATA2 (at 0x6249)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIMER_RDATA2                             = "
    tree.end
    tree "RTC_TIMER_SEC_ACCESS"
      sgroup "RTC_TIMER_SEC_ACCESS (at 0x62d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL1"
      sgroup "RTC_TIMER_PERPH_RESET_CTL1 (at 0x62d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (DEFAULT_DIS),1 (DEFAULT_EN)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL2"
      sgroup "RTC_TIMER_PERPH_RESET_CTL2 (at 0x62d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL3"
      sgroup "RTC_TIMER_PERPH_RESET_CTL3 (at 0x62da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "RTC_TIMER_PERPH_RESET_CTL4"
      sgroup "RTC_TIMER_PERPH_RESET_CTL4 (at 0x62db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "RTC_TIMER_INT_TEST1"
      sgroup "RTC_TIMER_INT_TEST1 (at 0x62e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_DIS),1 (INT_TEST_EN)"
    tree.end
    tree "RTC_TIMER_INT_TEST_VAL"
      sgroup "RTC_TIMER_INT_TEST_VAL (at 0x62e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        set &access:&cmd_addr %l 0x8062e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x6200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x62e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TIMER_EXPIRED_TEST_VAL                   = " "0 (INT_TEST_OUT_0),1 (INT_TEST_OUT_1)"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      sgroup "S1_CTRL_REVISION1 (at 0x11400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      sgroup "S1_CTRL_REVISION2 (at 0x11401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      sgroup "S1_CTRL_REVISION3 (at 0x11402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      sgroup "S1_CTRL_REVISION4 (at 0x11403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      sgroup "S1_CTRL_PERPH_TYPE (at 0x11404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      sgroup "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS1"
      sgroup "S1_CTRL_STATUS1 (at 0x11408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (VREG_ERR_FALSE),1 (VREG_ERR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_FAULT),1 (FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_TRUE                                  = " "0 (PS_TRUE_FALSE),1 (PS_TRUE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIME_SPEND_PWM_READY                     = " "0 (TIME_SPEND_PWM_READY_FALSE),1 (TIME_SPEND_PWM_READY_TRUE)"
    tree.end
    tree "S1_CTRL_STATUS2"
      sgroup "S1_CTRL_STATUS2 (at 0x11409)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIME_SPEND_PWM                           = "
    tree.end
    tree "S1_CTRL_STATUS3"
      sgroup "S1_CTRL_STATUS3 (at 0x1140a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80140a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x140a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   CAL_FAULT                                = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      sgroup "S1_CTRL_INT_RT_STS (at 0x11410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (VREG_FAULT_FALSE),1 (VREG_FAULT_TRUE)"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      sgroup "S1_CTRL_INT_SET_TYPE (at 0x11411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      sgroup "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      sgroup "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      sgroup "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      sgroup "S1_CTRL_INT_EN_SET (at 0x11415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      sgroup "S1_CTRL_INT_EN_CLR (at 0x11416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      sgroup "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      sgroup "S1_CTRL_INT_PENDING_STS (at 0x11419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      sgroup "S1_CTRL_INT_MID_SEL (at 0x1141a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      sgroup "S1_CTRL_INT_PRIORITY (at 0x1141b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S1_CTRL_VSET_LB"
      sgroup "S1_CTRL_VSET_LB (at 0x11440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "S1_CTRL_VSET_UB"
      sgroup "S1_CTRL_VSET_UB (at 0x11441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "S1_CTRL_VSET_VALID_LB"
      sgroup "S1_CTRL_VSET_VALID_LB (at 0x11442)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID_LB                            = "
    tree.end
    tree "S1_CTRL_VSET_VALID_UB"
      sgroup "S1_CTRL_VSET_VALID_UB (at 0x11443)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "S1_CTRL_PFM_CTL"
      sgroup "S1_CTRL_PFM_CTL (at 0x11444)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S1_CTRL_MODE_CTL1"
      sgroup "S1_CTRL_MODE_CTL1 (at 0x11445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S1_CTRL_EN_CTL"
      sgroup "S1_CTRL_EN_CTL (at 0x11446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S1_CTRL_FOLLOW_HWEN"
      sgroup "S1_CTRL_FOLLOW_HWEN (at 0x11447)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_AWAKE_CFG                         = " "0 (FOLLOW_AWAKE_CFG_FALSE),1 (FOLLOW_AWAKE_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HWEN2_CFG                         = " "0 (FOLLOW_HWEN2_CFG_FALSE),1 (FOLLOW_HWEN2_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_HWEN1_CFG                         = " "0 (FOLLOW_HWEN1_CFG_FALSE),1 (FOLLOW_HWEN1_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_HWEN0_CFG                         = " "0 (FOLLOW_HWEN0_CFG_FALSE),1 (FOLLOW_HWEN0_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HWEN2                          = " "0 (EN_FOLLOW_HWEN2_FALSE),1 (EN_FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HWEN1                          = " "0 (EN_FOLLOW_HWEN1_FALSE),1 (EN_FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HWEN0                          = " "0 (EN_FOLLOW_HWEN0_FALSE),1 (EN_FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S1_CTRL_PD_CTL"
      sgroup "S1_CTRL_PD_CTL (at 0x11448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ENABLE_FALSE),1 (STRONG_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_ENABLE_FALSE),1 (WEAK_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_PFM_FALSE),1 (WEAK_PD_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_PWM_FALSE),1 (WEAK_PD_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAK_PD_EN_FALSE),1 (LEAK_PD_EN_TRUE)"
    tree.end
    tree "S1_CTRL_MODE_CTL2"
      sgroup "S1_CTRL_MODE_CTL2 (at 0x11449)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S1_CTRL_RETENTION_CTL1"
      sgroup "S1_CTRL_RETENTION_CTL1 (at 0x1144a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80144a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x144a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_P1                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_M1                            = "
    tree.end
    tree "S1_CTRL_RETENTION_CTL2"
      sgroup "S1_CTRL_RETENTION_CTL2 (at 0x1144b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80144b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x144b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_X2                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_DIV2                          = "
    tree.end
    tree "S1_CTRL_RETENTION_STS1"
      sgroup "S1_CTRL_RETENTION_STS1 (at 0x1144c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80144c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x144c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_PERIOD                               = "
    tree.end
    tree "S1_CTRL_RETENTION_STS2"
      sgroup "S1_CTRL_RETENTION_STS2 (at 0x1144d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80144d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x144d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_COUNT                                = "
    tree.end
    tree "S1_CTRL_RETENTION_STS3"
      sgroup "S1_CTRL_RETENTION_STS3 (at 0x1144e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80144e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x144e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES                               = "
    tree.end
    tree "S1_CTRL_FREQ_CTL"
      sgroup "S1_CTRL_FREQ_CTL (at 0x11450)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S1_CTRL_COMP_CAP_C1_C2_CTL"
      sgroup "S1_CTRL_COMP_CAP_C1_C2_CTL (at 0x11451)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   C1_CTRL                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   C2_CTRL                                  = " "0 (C2_CAP_0P0_PF),1 (C2_CAP_0P2_PF),2 (C2_CAP_0P4_PF),3 (C2_CAP_0P6_PF)"
    tree.end
    tree "S1_CTRL_COMP_CAP_C3_CTL"
      sgroup "S1_CTRL_COMP_CAP_C3_CTL (at 0x11452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   C3_CTRL                                  = "
    tree.end
    tree "S1_CTRL_R1_R2_CTL"
      sgroup "S1_CTRL_R1_R2_CTL (at 0x11453)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   R1_CTL                                   = "
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   R2_CTL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_BUCK_SNS_CTL"
      sgroup "S1_CTRL_BUCK_SNS_CTL (at 0x11454)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SNS_SEL                                  = " "0 (SNS_SEL_0_VREG_SX),1 (SNS_SEL_1_VIN_LDO)"
    tree.end
    tree "S1_CTRL_RAMP_AMPLITUDE_CTL"
      sgroup "S1_CTRL_RAMP_AMPLITUDE_CTL (at 0x11456)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_FREQ_CTL_LOGIC                    = " "0 (FOLLOW_FREQ_CTL_LOGIC_0_RAMP_AMPLITUDE),1 (FOLLOW_FREQ_CTL_LOGIC_1_FREQ_CTL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMPAMPLITUDE                        = "
    tree.end
    tree "S1_CTRL_DMAX_CTL"
      sgroup "S1_CTRL_DMAX_CTL (at 0x11458)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_CTL"
      sgroup "S1_CTRL_PULSE_SKIP_CTL (at 0x11459)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_4CYCLE),1 (PS_TIME_HYST_8CYCLE),2 (PS_TIME_HYST_16CYCLE),3 (PS_TIME_HYST_32CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S1_CTRL_PS_THRES_ERRAMP"
      sgroup "S1_CTRL_PS_THRES_ERRAMP (at 0x1145a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ERRAMP                           = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_VRST_RANGE                            = " "0 (PS_VRST_RANGE_LOW),1 (PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VRST                                  = " "0 (PS_VRST_0MV),1 (PS_VRST_VOUTDIV30),2 (PS_VRST_VOUTDIV20),3 (PS_VRST_VOUTDIV15),4 (PS_VRST_VOUTDIV12),5 (PS_VRST_VOUTDIV10),6 (PS_VRST_VOUTDIV9),7 (PS_VRST_VOUTDIV8)"
    tree.end
    tree "S1_CTRL_AUTO_MODE_CTL"
      sgroup "S1_CTRL_AUTO_MODE_CTL (at 0x1145b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_32CYCLES)"
    tree.end
    tree "S1_CTRL_INZERO_COUNT_CTL"
      sgroup "S1_CTRL_INZERO_COUNT_CTL (at 0x1145c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PFM_COUNT_CTL"
      sgroup "S1_CTRL_PFM_COUNT_CTL (at 0x1145d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PS_THRES_ILOAD"
      sgroup "S1_CTRL_PS_THRES_ILOAD (at 0x1145e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ILOAD                            = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_METHOD_STEPPER                        = " "0 (PS_METHOD_STEPPER_ILOAD),1 (PS_METHOD_STEPPER_WINDOW)"
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      sgroup "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_STEPPER_DELAY                         = " "0 (STEPPER_SS_2_CLK_CYCLES),1 (STEPPER_SS_4_CLK_CYCLES),2 (STEPPER_SS_8_CLK_CYCLES),3 (STEPPER_SS_16_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      sgroup "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VS_STEPPER_DELAY                         = " "0 (STEPPER_VS_2_CLK_CYCLES),1 (STEPPER_VS_4_CLK_CYCLES),2 (STEPPER_VS_8_CLK_CYCLES),3 (STEPPER_VS_16_CLK_CYCLES)"
    tree.end
    tree "S1_CTRL_QM_PS_EXIT"
      sgroup "S1_CTRL_QM_PS_EXIT (at 0x11463)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QM_MODE                                  = " "0 (QM_MODE_FORCE_PFM_DITHER_ENABLED),1 (QM_MODE_FORCED_PWM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QM_FOLLOW                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QM_PS_METHOD                             = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QM_PS_VRST_RANGE                         = " "0 (QM_PS_VRST_RANGE_LOW),1 (QM_PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   QM_PS_VRST                               = " "0 (QM_PS_VRST_0MV),1 (QM_PS_VRST_VOUTDIV30),2 (QM_PS_VRST_VOUTDIV20),3 (QM_PS_VRST_VOUTDIV15),4 (QM_PS_VRST_VOUTDIV12),5 (QM_PS_VRST_VOUTDIV10),6 (QM_PS_VRST_VOUTDIV9),7 (QM_PS_VRST_VOUTDIV8)"
    tree.end
    tree "S1_CTRL_OCP"
      sgroup "S1_CTRL_OCP (at 0x11466)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_LATCH_EN                             = " "0 (OCP_LATCH_EN_FALSE),1 (OCP_LATCH_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_FOLDBACK_EN                         = " "0 (FORCE_FOLDBACK_FALSE),1 (FORCE_FOLDBACK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   INZERO_WAIT_OCP_TIMER                    = " "0 (INZERO_WAIT_40US_OCP_TIMER_320US),1 (INZERO_WAIT_80US_OCP_TIMER_640US),2 (INZERO_WAIT_160US_OCP_TIMER_1280_US),3 (INZERO_WAIT_160US_OCP_TIMER_1280US)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_EN_FALSE),1 (OCP_GLOBAL_BROADCAST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLEAR                         = " "0 (OCP_STATUS_CLEAR_FALSE),1 (OCP_STATUS_CLEAR_TRUE)"
    tree.end
    tree "S1_CTRL_ULS_VSET_LB"
      sgroup "S1_CTRL_ULS_VSET_LB (at 0x11468)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "S1_CTRL_ULS_VSET_UB"
      sgroup "S1_CTRL_ULS_VSET_UB (at 0x11469)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "S1_CTRL_STATUS_DEB_CTL"
      sgroup "S1_CTRL_STATUS_DEB_CTL (at 0x11470)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_0_LFRC_DIV2),1 (READY_DEB_1_LFRC_DIV4),2 (READY_DEB_2_LFRC_DIV8),3 (READY_DEB_3_LFRC_DIV16)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_0_LFRC_DIV2),1 (ERROR_DEB_1_LFRC_DIV4),2 (ERROR_DEB_2_LFRC_DIV8),3 (ERROR_DEB_3_LFRC_DIV16)"
    tree.end
    tree "S1_CTRL_CAL_TIMER_CTL"
      sgroup "S1_CTRL_CAL_TIMER_CTL (at 0x11471)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER                                = "
    tree.end
    tree "S1_CTRL_CAL_START"
      sgroup "S1_CTRL_CAL_START (at 0x11472)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQ_WR_PULSE                         = " "0 (CAL_REQ_WR_PULSE_FALSE),1 (CAL_REQ_WR_PULSE_TRUE)"
    tree.end
    tree "S1_CTRL_CAL_TRIM1"
      sgroup "S1_CTRL_CAL_TRIM1 (at 0x11473)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERR_AMP_TRIM_AUTO                        = "
    tree.end
    tree "S1_CTRL_CAL_TRIM2"
      sgroup "S1_CTRL_CAL_TRIM2 (at 0x11474)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM_AUTO                      = "
    tree.end
    tree "S1_CTRL_CAL_TRIM3"
      sgroup "S1_CTRL_CAL_TRIM3 (at 0x11475)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM_AUTO                       = "
    tree.end
    tree "S1_CTRL_CAL_TRIM4"
      sgroup "S1_CTRL_CAL_TRIM4 (at 0x11476)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM_AUTO                      = "
    tree.end
    tree "S1_CTRL_CAL_TRIM5"
      sgroup "S1_CTRL_CAL_TRIM5 (at 0x11477)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM_AUTO                  = "
    tree.end
    tree "S1_CTRL_CAL_TRIM_EN_CTL"
      sgroup "S1_CTRL_CAL_TRIM_EN_CTL (at 0x11478)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ERR_AMP_TRIM_CAL_EN                      = " "0 (reserved),1 (ERR_AMP_TRIM_CAL_EN_MAN),2 (reserved),3 (ERR_AMP_TRIM_CAL_EN_AUTO)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PWM_THRES_TRIM_CAL_EN                    = " "0 (PWM_THRES_TRIM_CAL_EN_MAN),1 (PWM_THRES_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_TRIM_CAL_EN                     = " "0 (PFM_COMP_TRIM_CAL_EN_MAN),1 (PFM_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VDIP_COMP_TRIM_CAL_EN                    = " "0 (VDIP_COMP_TRIM_CAL_EN_MAN),1 (VDIP_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_RAMP_PEAK_TRIM_CAL_EN                = " "0 (PWM_RAMP_PEAK_TRIM_CAL_EN_MAN),1 (PWM_RAMP_PEAK_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_CAL_ENG_EN                          = " "0 (TRIM_CAL_ENG_EN_FALSE),1 (TRIM_CAL_ENG_EN_TRUE)"
    tree.end
    tree "S1_CTRL_CTLR_MISC"
      sgroup "S1_CTRL_CTLR_MISC (at 0x1147e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80147e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x147e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIS_PFM_DIR_SAMPLE                       = " "0 (DIS_PFM_DIR_SAMPLE_FALSE),1 (DIS_PFM_DIR_SAMPLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIS_VDIP_HCPFM_GATE                      = " "0 (DIS_VDIP_HCPFM_GATE_FALSE),1 (DIS_VDIP_HCPFM_GATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_PRECH_EXTEND                         = " "0 (DIS_PRECH_EXTEND_FALSE),1 (DIS_PRECH_EXTEND_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_FORCE_PWM                            = " "0 (DIS_FORCE_PWM_FALSE),1 (DIS_FORCE_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_CLAMP                                = " "0 (DIS_CLAMP_FALSE),1 (DIS_CLAMP_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PS_TIMEOUT                           = " "0 (DIS_PS_TIMEOUT_FALSE),1 (DIS_PS_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_ERRAMP_TRIM_BUF                      = " "0 (DIS_ERRAMP_TRIM_BUF_FALSE),1 (DIS_ERRAMP_TRIM_BUF_TRUE)"
    tree.end
    tree "S1_CTRL_SCRATCH_REG"
      sgroup "S1_CTRL_SCRATCH_REG (at 0x1147f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80147f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x147f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SCRATCH_7                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCRATCH_6                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCRATCH_5                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCRATCH_4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SCRATCH_3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SCRATCH_2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SCRATCH_1                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SCRATCH_0                                = " "0, 1"
    tree.end
    tree "S1_CTRL_GANG_CTL1"
      sgroup "S1_CTRL_GANG_CTL1 (at 0x114c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_CTRL_GANG_CTL2"
      sgroup "S1_CTRL_GANG_CTL2 (at 0x114c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      sgroup "S1_CTRL_SEC_ACCESS (at 0x114d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      sgroup "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      sgroup "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      sgroup "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      sgroup "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      sgroup "S1_CTRL_INT_TEST1 (at 0x114e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      sgroup "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT_TEST_VAL                  = " "0 (VREG_READY_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_READY_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_FAULT_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S1_CTRL_CTLR_TEST1"
      sgroup "S1_CTRL_CTLR_TEST1 (at 0x114e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_SEL_NORMAL_OPERATION),1 (ATEST1_SEL_ERR_AMP_OUT),2 (ATEST1_SEL_VREF_DAC),3 (ATEST1_SEL_VRAMP_PK),4 (ATEST1_SEL_VREF_RESET),5 (ATEST1_SEL_VRAMP),6 (ATEST1_SEL_VFB_DIV_PFM),7 (ATEST1_SEL_ERR_AMP_IN_MNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_SEL_NORMAL_OPERATION),1 (DTEST1_SEL_BUCK_CLK),2 (DTEST1_SEL_PS_COMP),3 (DTEST1_SEL_PULSE_SKIP_FSM),4 (DTEST1_SEL_PWM_COMP),5 (DTEST1_SEL_LO_COMP_FSM),6 (DTEST1_SEL_PFM_COMP_FSM),7 (DTEST1_SEL_MODE_FSM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_CTRL_CTLR_TEST2"
      sgroup "S1_CTRL_CTLR_TEST2 (at 0x114e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_SEL_NORMAL_OPERATION),1 (ATEST2_SEL_VREF_DAC_EA),2 (ATEST2_SEL_A_REG_GNDC),3 (ATEST2_SEL_VRAMP_BOT),4 (ATEST2_SEL_ERRAMP_OUT),5 (ATEST2_SEL_AVDD),6 (ATEST2_SEL_VFB_DIV_PSKIP),7 (ATEST2_SEL_VOUT_SNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_SEL_NORMAL_OPERATION),1 (DTEST2_SEL_CLK_LFRC),2 (DTEST2_SEL_INZ_CNT_DONE),3 (DTEST2_SEL_PDRV_EXTEND),4 (DTEST2_SEL_PS_EXIT),5 (DTEST2_SEL_PS_ENTER_WIN),6 (DTEST2_SEL_IPLIM_INT_MODE),7 (DTEST2_SEL_FORCE_PS_FOLDBACK)"
    tree.end
    tree "S1_CTRL_CTLR_TEST3"
      sgroup "S1_CTRL_CTLR_TEST3 (at 0x114e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST3_SEL                               = " "0 (DTEST3_SEL_NORMAL_OPERATION),1 (DTEST3_SEL_ERRAMP_DIG),2 (DTEST3_SEL_VRAMP_COMP_DIG),3 (DTEST3_SEL_PFM_COMP_CNTR),4 (DTEST3_SEL_VDIP_COMP),5 (DTEST3_SEL_TRIM_MUX_OUT),6 (DTEST3_SEL_CLAMP_ON),7 (DTEST3_SEL_RAMP_RST)"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      sgroup "S1_CTRL_TRIM_NUM (at 0x114f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CAL_MANUAL"
      sgroup "S1_CTRL_CAL_MANUAL (at 0x114f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MAN_CAL                                  = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      sgroup "S1_CTRL_CTL_TRIM1 (at 0x114f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM                           = "
    tree.end
    tree "S1_CTRL_CTL_TRIM2"
      sgroup "S1_CTRL_CTL_TRIM2 (at 0x114f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM                            = "
    tree.end
    tree "S1_CTRL_CTL_TRIM4"
      sgroup "S1_CTRL_CTL_TRIM4 (at 0x114f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S1_CTRL_CTL_TRIM3"
      sgroup "S1_CTRL_CTL_TRIM3 (at 0x114f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      sgroup "S1_FREQ_REVISION1 (at 0x11600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      sgroup "S1_FREQ_REVISION2 (at 0x11601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      sgroup "S1_FREQ_PERPH_TYPE (at 0x11604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      sgroup "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      sgroup "S1_FREQ_CLK_ENABLE (at 0x11646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      sgroup "S1_FREQ_CLK_DIV (at 0x11650)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      sgroup "S1_FREQ_CLK_PHASE (at 0x11651)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      sgroup "S1_FREQ_GANG_CTL1 (at 0x116c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      sgroup "S1_FREQ_GANG_CTL2 (at 0x116c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      sgroup "S1_FREQ_SEC_ACCESS (at 0x116d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      sgroup "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      sgroup "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      sgroup "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S1_FREQ_TEST1"
      sgroup "S1_FREQ_TEST1 (at 0x116e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      sgroup "S1_PS_REVISION1 (at 0x11500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      sgroup "S1_PS_REVISION2 (at 0x11501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      sgroup "S1_PS_REVISION3 (at 0x11502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      sgroup "S1_PS_REVISION4 (at 0x11503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      sgroup "S1_PS_PERPH_TYPE (at 0x11504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      sgroup "S1_PS_PERPH_SUBTYPE (at 0x11505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_STATUS3"
      sgroup "S1_PS_STATUS3 (at 0x1150a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80150a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x150a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
    tree.end
    tree "S1_PS_STATUS4"
      sgroup "S1_PS_STATUS4 (at 0x1150b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80150b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x150b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (ECM_MISSED_DATA_FALSE),1 (ECM_MISSED_DATA_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ECM_DATA_TYPE                            = " "0 (ECM_DATA_TYPE_MEASUREMENT),1 (ECM_DATA_TYPE_REFERENCE),2 (ECM_DATA_TYPE_OFFSET),3 (ECM_DATA_TYPE_RESERVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_PRESENT_FALSE),1 (ECM_PRESENT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ECM_REQ_SW_CALIB                         = " "0 (ECM_REQ_SW_CALIB_FALSE),1 (ECM_REQ_SW_CALIB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ECM_DATA_NEGATIVE                        = " "0 (ECM_DATA_NEGATIVE_FALSE),1 (ECM_DATA_NEGATIVE_TRUE)"
    tree.end
    tree "S1_PS_PFM_FREQ_CTL"
      sgroup "S1_PS_PFM_FREQ_CTL (at 0x11544)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_FREQ_DITH_EN                         = " "0 (PFM_DITHERING_EN_FALSE),1 (PFM_DITHERING_EN_TRUE)"
    tree.end
    tree "S1_PS_PFM_FREQ_CFG"
      sgroup "S1_PS_PFM_FREQ_CFG (at 0x11545)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FREQ_DITH_NUMBIT_SEL                     = " "0 (NUMBIT_SEL_2B),1 (NUMBIT_SEL_3B)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DITH_TIMING_CTL                          = " "0 (DITH_CTL_PFM_COMP_CLK),1 (DITH_CTL_PFM_COMP_DIV4_CLK),2 (DITH_CTL_PFM_COMP_DIV32_CLK),3 (DITH_CTL_PFM_COMP_DIV128_CLK),4 (DITH_CTL_LFRC_CLK),5 (DITH_CTL_LFRC_DIV4_CLK),6 (DITH_CTL_LFRC_DIV32_CLK),7 (DITH_CTL_LFRC_DIV128_CLK)"
    tree.end
    tree "S1_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PWM_CURRENT_LIM_CTL (at 0x1154a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CURRENT_LIM_AUTOINT_SEL                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PWM_SEL                      = "
    tree.end
    tree "S1_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PFM_CURRENT_LIM_CTL (at 0x1154b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_PWM_CURRENT_LIM_EN                   = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PFM_SEL                      = "
    tree.end
    tree "S1_PS_ILIM_SS_CTL"
      sgroup "S1_PS_ILIM_SS_CTL (at 0x1154c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ILIM_SS_SEL                              = "
    tree.end
    tree "S1_PS_ISNS_THRES"
      sgroup "S1_PS_ISNS_THRES (at 0x1155a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80155a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x155a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_ENTRY_AUTO                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PS_ENTRY_PWM                             = "
    tree.end
    tree "S1_PS_QM_PS_ENTRY"
      sgroup "S1_PS_QM_PS_ENTRY (at 0x11563)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_ENTRY                           = "
    tree.end
    tree "S1_PS_SWITCH_SIZE_CTL"
      sgroup "S1_PS_SWITCH_SIZE_CTL (at 0x11570)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_MIN),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_MIN),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL"
      sgroup "S1_PS_DEAD_TIME_CTRL (at 0x11572)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      sgroup "S1_PS_BLNK_TIME_CTL (at 0x11573)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S1_PS_INZERO_CTL"
      sgroup "S1_PS_INZERO_CTL (at 0x11574)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S1_PS_DIG_FSM_CTL"
      sgroup "S1_PS_DIG_FSM_CTL (at 0x11575)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_LAT_DIS                              = " "0 (FSM_DISABLE_LATCH_FALSE),1 (FSM_DISABLE_LATCH_TRUE)"
    tree.end
    tree "S1_PS_CAL_EN_CTL1"
      sgroup "S1_PS_CAL_EN_CTL1 (at 0x11578)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIM_TRIM_CAL_EN                        = " "0 (IPLIM_TRIM_CAL_EN_FALSE),1 (IPLIM_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_THRES_TRIM_CAL_EN                   = " "0 (AUTO_THRES_TRIM_CAL_EN_FALSE),1 (AUTO_THRES_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INZERO_TRIM_CAL_EN                       = " "0 (INZERO_TRIM_CAL_EN_FALSE),1 (INZERO_TRIM_CAL_EN_TRUE)"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      sgroup "S1_PS_PWR_STG_MISC (at 0x1157e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80157e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x157e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0 (DUTY_EST_CLK_SEL_BIT1_FALSE),1 (DUTY_EST_CLK_SEL_BIT1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0 (DUTY_EST_CLK_SEL_BIT0_FALSE),1 (DUTY_EST_CLK_SEL_BIT0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0 (AUTO_BLOCK_THRESH_NORMAL),1 (AUTO_BLOCK_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0 (PFM_CURRENT_LIMIT_THRESH_NORMAL),1 (PFM_CURRENT_LIMIT_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (AUTO_MODE_BW_SEL_NORMAL),1 (AUTO_MODE_BW_SEL_QUARTER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0 (BYPASS_CMN_MODE_ECM_FALSE),1 (BYPASS_CMN_MODE_ECM_TRUE)"
    tree.end
    tree "S1_PS_ECM_EN_CTL"
      sgroup "S1_PS_ECM_EN_CTL (at 0x11580)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_EN_FALSE),1 (ECM_LOCAL_EN_TRUE)"
    tree.end
    tree "S1_PS_ECM_CFG_0"
      sgroup "S1_PS_ECM_CFG_0 (at 0x11581)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SENSE_SW_NTWK_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   FET_REF_SIZE_SEL                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_ADC_REF_CHOPPING                      = " "0 (EN_ADC_REF_CHOPPING_FALSE),1 (EN_ADC_REF_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_ADC_IN_CHOPPING                       = " "0 (EN_ADC_IN_CHOPPING_FALSE),1 (EN_ADC_IN_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SENSE_FILT_BW_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ADC_GAIN_SEL                             = " "0 (ADC_GAIN_SEL_GAIN_OF_2),1 (ADC_GAIN_SEL_GAIN_OF_3),2 (ADC_GAIN_SEL_GAIN_OF_3P0),3 (ADC_GAIN_SEL_GAIN_OF_4)"
    tree.end
    tree "S1_PS_ECM_CFG_1"
      sgroup "S1_PS_ECM_CFG_1 (at 0x11582)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   ECM_BIAS_CTRL                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ECM_REF_OFF_CTRL                         = " "0 (ECM_REF_OFF_CTRL_0),1 (ECM_REF_OFF_CTRL_1),2 (ECM_REF_OFF_CTRL_2),3 (ECM_REF_OFF_CTRL_3),4 (ECM_REF_OFF_CTRL_4),5 (ECM_REF_OFF_CTRL_5),6 (ECM_REF_OFF_CTRL_6),7 (ECM_REF_OFF_CTRL_7)"
    tree.end
    tree "S1_PS_ECM_DATA_LB"
      sgroup "S1_PS_ECM_DATA_LB (at 0x11584)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "S1_PS_ECM_DATA_UB"
      sgroup "S1_PS_ECM_DATA_UB (at 0x11585)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "S1_PS_SEC_ACCESS"
      sgroup "S1_PS_SEC_ACCESS (at 0x115d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      sgroup "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      sgroup "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      sgroup "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S1_PS_FORCE_FET_TEST"
      sgroup "S1_PS_FORCE_FET_TEST (at 0x115e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S1_PS_PWR_STG_TEST1"
      sgroup "S1_PS_PWR_STG_TEST1 (at 0x115e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_NORMAL),1 (ATEST1_FET_KSP1),2 (ATEST1_REF_KSP1),3 (ATEST1_ECM_OUT_CM),4 (ATEST1_A_ECM_ATEST_FORCE1),5 (ATEST1_VREF_FILT),6 (ATEST1_VREF_SNS),7 (ATEST1_FLOATING)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_MISSION_MODE),1 (DTEST1_D_AUTO_PS_THRES_COMP),2 (DTEST1_D_DC_VOUT_CLK_1),3 (DTEST1_D_PSW_DRV_SEL),4 (DTEST1_D_INZ_COMP_LOC),5 (DTEST1_D_IPLIM_COMP_LOC),6 (DTEST1_ECM_PHI1),7 (DTEST1_D_NSW_DRV_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S1_PS_PWR_STG_TEST2"
      sgroup "S1_PS_PWR_STG_TEST2 (at 0x115e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_MISSION_MODE),1 (ATEST2_FET_KSP2),2 (ATEST2_REF_KSP2),3 (ATEST2_ECM_VBIAS),4 (ATEST2_A_ECM_ATEST_FORCE2),5 (ATEST2_VSW_FILT),6 (ATEST2_VSW_SNS),7 (ATEST2_SPARE)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_MISSION_MODE),1 (DTEST2_D_END_MIN_PON),2 (DTEST2_D_DC_COMP_OUT),3 (DTEST2_D_PFM_ENTRY_BUF),4 (DTEST2_D_INZ_COMP_EXTEND),5 (DTEST2_D_PGATE_BLNK),6 (DTEST2_ECM_PHI2),7 (DTEST2_D_PSK_ENTRY_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIM_TEST_CTRL                          = " "0 (IPLIM_TEST_MODE_CTRL_RESERVED_0),1 (IPLIM_TEST_MODE_CTRL_RESERVED_1),2 (IPLIM_TEST_MODE_CTRL_RESERVED_2),3 (IPLIM_TEST_MODE_CTRL_RESERVED_3)"
    tree.end
    tree "S1_PS_PWR_STG_TEST3"
      sgroup "S1_PS_PWR_STG_TEST3 (at 0x115e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST3_SEL                               = " "0 (DTEST3_MISSION_MODE),1 (DTEST3_D_D2A_ECM_DTEST_DEC_0_D_D2A_ECM_ADC_INPUT_POLARITY),2 (DTEST3_D_D2A_ECM_DTEST_DEC_2_D_D2A_ECM_ADC_INPUT_MUX_CTRL_1),3 (DTEST3_D_D2A_ECM_DTEST_DEC_4_D_CHOP_SYNC),4 (DTEST3_D_D2A_ECM_DTEST_DEC_6_D_CAL_STROBE),5 (DTEST3_CAL_MUX_FILT_OUT),6 (DTEST3_ECM_COMP_P),7 (DTEST3_ECM_COMP_N)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST4_SEL                               = " "0 (DTEST4_MISSION_MODE),1 (DTEST4_D_D2A_ECM_DTEST_DEC_1_D_D2A_ECM_ADC_INPUT_MUX_CTRL_0),2 (DTEST4_D_D2A_ECM_DTEST_DEC_3_D_D2A_ECM_ADC_INPUT_MUX_CTRL_2),3 (DTEST4_D_D2A_ECM_DTEST_DEC_5_D_GLOBAL_EN),4 (DTEST4_D_D2A_ECM_DTEST_DEC_7_D_STROBE),5 (DTEST4_SPARE),6 (DTEST4_ECM_ADC_INPUT_POLARITY),7 (DTEST4_D_ADC_CLR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SENSE                                 = " "0 (EN_SENSE_FALSE),1 (EN_SENSE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_ADC                                   = " "0 (EN_ADC_FALSE),1 (EN_ADC_TRUE)"
    tree.end
    tree "S1_PS_PWR_STG_TEST4"
      sgroup "S1_PS_PWR_STG_TEST4 (at 0x115e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_TEST_EN                              = " "0 (ECM_TEST_EN_FALSE),1 (ECM_TEST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ECM_INPUT_MUX_CTRL                       = " "0 (ECM_INPUT_MUX_CTRL_0),1 (ECM_INPUT_MUX_CTRL_1),2 (ECM_INPUT_MUX_CTRL_2),3 (ECM_INPUT_MUX_CTRL_3),4 (ECM_INPUT_MUX_CTRL_4),5 (ECM_INPUT_MUX_CTRL_5),6 (ECM_INPUT_MUX_CTRL_6),7 (ECM_INPUT_MUX_CTRL_7)"
    tree.end
    tree "S1_PS_TRIM_NUM"
      sgroup "S1_PS_TRIM_NUM (at 0x115f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      sgroup "S1_PS_PS_TRIM1 (at 0x115f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IPLIM_TRIM                               = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      sgroup "S1_PS_PS_TRIM2 (at 0x115f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S1_PS_PS_TRIM3"
      sgroup "S1_PS_PS_TRIM3 (at 0x115f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AUTO_THRS_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      sgroup "S2_CTRL_REVISION1 (at 0x11700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      sgroup "S2_CTRL_REVISION2 (at 0x11701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      sgroup "S2_CTRL_REVISION3 (at 0x11702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      sgroup "S2_CTRL_REVISION4 (at 0x11703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      sgroup "S2_CTRL_PERPH_TYPE (at 0x11704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      sgroup "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS1"
      sgroup "S2_CTRL_STATUS1 (at 0x11708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (VREG_ERR_FALSE),1 (VREG_ERR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_FAULT),1 (FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_TRUE                                  = " "0 (PS_TRUE_FALSE),1 (PS_TRUE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIME_SPEND_PWM_READY                     = " "0 (TIME_SPEND_PWM_READY_FALSE),1 (TIME_SPEND_PWM_READY_TRUE)"
    tree.end
    tree "S2_CTRL_STATUS2"
      sgroup "S2_CTRL_STATUS2 (at 0x11709)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIME_SPEND_PWM                           = "
    tree.end
    tree "S2_CTRL_STATUS3"
      sgroup "S2_CTRL_STATUS3 (at 0x1170a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80170a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x170a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   CAL_FAULT                                = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      sgroup "S2_CTRL_INT_RT_STS (at 0x11710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (VREG_FAULT_FALSE),1 (VREG_FAULT_TRUE)"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      sgroup "S2_CTRL_INT_SET_TYPE (at 0x11711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      sgroup "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      sgroup "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      sgroup "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      sgroup "S2_CTRL_INT_EN_SET (at 0x11715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      sgroup "S2_CTRL_INT_EN_CLR (at 0x11716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      sgroup "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      sgroup "S2_CTRL_INT_PENDING_STS (at 0x11719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      sgroup "S2_CTRL_INT_MID_SEL (at 0x1171a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      sgroup "S2_CTRL_INT_PRIORITY (at 0x1171b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S2_CTRL_VSET_LB"
      sgroup "S2_CTRL_VSET_LB (at 0x11740)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "S2_CTRL_VSET_UB"
      sgroup "S2_CTRL_VSET_UB (at 0x11741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "S2_CTRL_VSET_VALID_LB"
      sgroup "S2_CTRL_VSET_VALID_LB (at 0x11742)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID_LB                            = "
    tree.end
    tree "S2_CTRL_VSET_VALID_UB"
      sgroup "S2_CTRL_VSET_VALID_UB (at 0x11743)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "S2_CTRL_PFM_CTL"
      sgroup "S2_CTRL_PFM_CTL (at 0x11744)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S2_CTRL_MODE_CTL1"
      sgroup "S2_CTRL_MODE_CTL1 (at 0x11745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S2_CTRL_EN_CTL"
      sgroup "S2_CTRL_EN_CTL (at 0x11746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S2_CTRL_FOLLOW_HWEN"
      sgroup "S2_CTRL_FOLLOW_HWEN (at 0x11747)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_AWAKE_CFG                         = " "0 (FOLLOW_AWAKE_CFG_FALSE),1 (FOLLOW_AWAKE_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HWEN2_CFG                         = " "0 (FOLLOW_HWEN2_CFG_FALSE),1 (FOLLOW_HWEN2_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_HWEN1_CFG                         = " "0 (FOLLOW_HWEN1_CFG_FALSE),1 (FOLLOW_HWEN1_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_HWEN0_CFG                         = " "0 (FOLLOW_HWEN0_CFG_FALSE),1 (FOLLOW_HWEN0_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HWEN2                          = " "0 (EN_FOLLOW_HWEN2_FALSE),1 (EN_FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HWEN1                          = " "0 (EN_FOLLOW_HWEN1_FALSE),1 (EN_FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HWEN0                          = " "0 (EN_FOLLOW_HWEN0_FALSE),1 (EN_FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S2_CTRL_PD_CTL"
      sgroup "S2_CTRL_PD_CTL (at 0x11748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ENABLE_FALSE),1 (STRONG_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_ENABLE_FALSE),1 (WEAK_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_PFM_FALSE),1 (WEAK_PD_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_PWM_FALSE),1 (WEAK_PD_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAK_PD_EN_FALSE),1 (LEAK_PD_EN_TRUE)"
    tree.end
    tree "S2_CTRL_MODE_CTL2"
      sgroup "S2_CTRL_MODE_CTL2 (at 0x11749)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S2_CTRL_RETENTION_CTL1"
      sgroup "S2_CTRL_RETENTION_CTL1 (at 0x1174a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_P1                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_M1                            = "
    tree.end
    tree "S2_CTRL_RETENTION_CTL2"
      sgroup "S2_CTRL_RETENTION_CTL2 (at 0x1174b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_X2                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_DIV2                          = "
    tree.end
    tree "S2_CTRL_RETENTION_STS1"
      sgroup "S2_CTRL_RETENTION_STS1 (at 0x1174c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_PERIOD                               = "
    tree.end
    tree "S2_CTRL_RETENTION_STS2"
      sgroup "S2_CTRL_RETENTION_STS2 (at 0x1174d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_COUNT                                = "
    tree.end
    tree "S2_CTRL_RETENTION_STS3"
      sgroup "S2_CTRL_RETENTION_STS3 (at 0x1174e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80174e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x174e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES                               = "
    tree.end
    tree "S2_CTRL_FREQ_CTL"
      sgroup "S2_CTRL_FREQ_CTL (at 0x11750)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_CTRL_COMP_CAP_C1_C2_CTL"
      sgroup "S2_CTRL_COMP_CAP_C1_C2_CTL (at 0x11751)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   C1_CTRL                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   C2_CTRL                                  = " "0 (C2_CAP_0P0_PF),1 (C2_CAP_0P2_PF),2 (C2_CAP_0P4_PF),3 (C2_CAP_0P6_PF)"
    tree.end
    tree "S2_CTRL_COMP_CAP_C3_CTL"
      sgroup "S2_CTRL_COMP_CAP_C3_CTL (at 0x11752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   C3_CTRL                                  = "
    tree.end
    tree "S2_CTRL_R1_R2_CTL"
      sgroup "S2_CTRL_R1_R2_CTL (at 0x11753)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   R1_CTL                                   = "
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   R2_CTL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_BUCK_SNS_CTL"
      sgroup "S2_CTRL_BUCK_SNS_CTL (at 0x11754)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SNS_SEL                                  = " "0 (SNS_SEL_0_VREG_SX),1 (SNS_SEL_1_VIN_LDO)"
    tree.end
    tree "S2_CTRL_RAMP_AMPLITUDE_CTL"
      sgroup "S2_CTRL_RAMP_AMPLITUDE_CTL (at 0x11756)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_FREQ_CTL_LOGIC                    = " "0 (FOLLOW_FREQ_CTL_LOGIC_0_RAMP_AMPLITUDE),1 (FOLLOW_FREQ_CTL_LOGIC_1_FREQ_CTL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMPAMPLITUDE                        = "
    tree.end
    tree "S2_CTRL_DMAX_CTL"
      sgroup "S2_CTRL_DMAX_CTL (at 0x11758)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S2_CTRL_PULSE_SKIP_CTL"
      sgroup "S2_CTRL_PULSE_SKIP_CTL (at 0x11759)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_4CYCLE),1 (PS_TIME_HYST_8CYCLE),2 (PS_TIME_HYST_16CYCLE),3 (PS_TIME_HYST_32CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S2_CTRL_PS_THRES_ERRAMP"
      sgroup "S2_CTRL_PS_THRES_ERRAMP (at 0x1175a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ERRAMP                           = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_VRST_RANGE                            = " "0 (PS_VRST_RANGE_LOW),1 (PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VRST                                  = " "0 (PS_VRST_0MV),1 (PS_VRST_VOUTDIV30),2 (PS_VRST_VOUTDIV20),3 (PS_VRST_VOUTDIV15),4 (PS_VRST_VOUTDIV12),5 (PS_VRST_VOUTDIV10),6 (PS_VRST_VOUTDIV9),7 (PS_VRST_VOUTDIV8)"
    tree.end
    tree "S2_CTRL_AUTO_MODE_CTL"
      sgroup "S2_CTRL_AUTO_MODE_CTL (at 0x1175b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_32CYCLES)"
    tree.end
    tree "S2_CTRL_INZERO_COUNT_CTL"
      sgroup "S2_CTRL_INZERO_COUNT_CTL (at 0x1175c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S2_CTRL_PFM_COUNT_CTL"
      sgroup "S2_CTRL_PFM_COUNT_CTL (at 0x1175d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S2_CTRL_PS_THRES_ILOAD"
      sgroup "S2_CTRL_PS_THRES_ILOAD (at 0x1175e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80175e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x175e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ILOAD                            = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_METHOD_STEPPER                        = " "0 (PS_METHOD_STEPPER_ILOAD),1 (PS_METHOD_STEPPER_WINDOW)"
    tree.end
    tree "S2_CTRL_STEPPER_SS_CTL"
      sgroup "S2_CTRL_STEPPER_SS_CTL (at 0x11760)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_STEPPER_DELAY                         = " "0 (STEPPER_SS_2_CLK_CYCLES),1 (STEPPER_SS_4_CLK_CYCLES),2 (STEPPER_SS_8_CLK_CYCLES),3 (STEPPER_SS_16_CLK_CYCLES)"
    tree.end
    tree "S2_CTRL_STEPPER_VS_CTL"
      sgroup "S2_CTRL_STEPPER_VS_CTL (at 0x11761)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VS_STEPPER_DELAY                         = " "0 (STEPPER_VS_2_CLK_CYCLES),1 (STEPPER_VS_4_CLK_CYCLES),2 (STEPPER_VS_8_CLK_CYCLES),3 (STEPPER_VS_16_CLK_CYCLES)"
    tree.end
    tree "S2_CTRL_QM_PS_EXIT"
      sgroup "S2_CTRL_QM_PS_EXIT (at 0x11763)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QM_MODE                                  = " "0 (QM_MODE_FORCE_PFM_DITHER_ENABLED),1 (QM_MODE_FORCED_PWM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QM_FOLLOW                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QM_PS_METHOD                             = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QM_PS_VRST_RANGE                         = " "0 (QM_PS_VRST_RANGE_LOW),1 (QM_PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   QM_PS_VRST                               = " "0 (QM_PS_VRST_0MV),1 (QM_PS_VRST_VOUTDIV30),2 (QM_PS_VRST_VOUTDIV20),3 (QM_PS_VRST_VOUTDIV15),4 (QM_PS_VRST_VOUTDIV12),5 (QM_PS_VRST_VOUTDIV10),6 (QM_PS_VRST_VOUTDIV9),7 (QM_PS_VRST_VOUTDIV8)"
    tree.end
    tree "S2_CTRL_OCP"
      sgroup "S2_CTRL_OCP (at 0x11766)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_LATCH_EN                             = " "0 (OCP_LATCH_EN_FALSE),1 (OCP_LATCH_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_FOLDBACK_EN                         = " "0 (FORCE_FOLDBACK_FALSE),1 (FORCE_FOLDBACK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   INZERO_WAIT_OCP_TIMER                    = " "0 (INZERO_WAIT_40US_OCP_TIMER_320US),1 (INZERO_WAIT_80US_OCP_TIMER_640US),2 (INZERO_WAIT_160US_OCP_TIMER_1280_US),3 (INZERO_WAIT_160US_OCP_TIMER_1280US)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_EN_FALSE),1 (OCP_GLOBAL_BROADCAST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLEAR                         = " "0 (OCP_STATUS_CLEAR_FALSE),1 (OCP_STATUS_CLEAR_TRUE)"
    tree.end
    tree "S2_CTRL_ULS_VSET_LB"
      sgroup "S2_CTRL_ULS_VSET_LB (at 0x11768)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "S2_CTRL_ULS_VSET_UB"
      sgroup "S2_CTRL_ULS_VSET_UB (at 0x11769)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "S2_CTRL_STATUS_DEB_CTL"
      sgroup "S2_CTRL_STATUS_DEB_CTL (at 0x11770)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_0_LFRC_DIV2),1 (READY_DEB_1_LFRC_DIV4),2 (READY_DEB_2_LFRC_DIV8),3 (READY_DEB_3_LFRC_DIV16)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_0_LFRC_DIV2),1 (ERROR_DEB_1_LFRC_DIV4),2 (ERROR_DEB_2_LFRC_DIV8),3 (ERROR_DEB_3_LFRC_DIV16)"
    tree.end
    tree "S2_CTRL_CAL_TIMER_CTL"
      sgroup "S2_CTRL_CAL_TIMER_CTL (at 0x11771)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER                                = "
    tree.end
    tree "S2_CTRL_CAL_START"
      sgroup "S2_CTRL_CAL_START (at 0x11772)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQ_WR_PULSE                         = " "0 (CAL_REQ_WR_PULSE_FALSE),1 (CAL_REQ_WR_PULSE_TRUE)"
    tree.end
    tree "S2_CTRL_CAL_TRIM1"
      sgroup "S2_CTRL_CAL_TRIM1 (at 0x11773)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERR_AMP_TRIM_AUTO                        = "
    tree.end
    tree "S2_CTRL_CAL_TRIM2"
      sgroup "S2_CTRL_CAL_TRIM2 (at 0x11774)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM_AUTO                      = "
    tree.end
    tree "S2_CTRL_CAL_TRIM3"
      sgroup "S2_CTRL_CAL_TRIM3 (at 0x11775)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM_AUTO                       = "
    tree.end
    tree "S2_CTRL_CAL_TRIM4"
      sgroup "S2_CTRL_CAL_TRIM4 (at 0x11776)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM_AUTO                      = "
    tree.end
    tree "S2_CTRL_CAL_TRIM5"
      sgroup "S2_CTRL_CAL_TRIM5 (at 0x11777)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM_AUTO                  = "
    tree.end
    tree "S2_CTRL_CAL_TRIM_EN_CTL"
      sgroup "S2_CTRL_CAL_TRIM_EN_CTL (at 0x11778)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ERR_AMP_TRIM_CAL_EN                      = " "0 (reserved),1 (ERR_AMP_TRIM_CAL_EN_MAN),2 (reserved),3 (ERR_AMP_TRIM_CAL_EN_AUTO)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PWM_THRES_TRIM_CAL_EN                    = " "0 (PWM_THRES_TRIM_CAL_EN_MAN),1 (PWM_THRES_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_TRIM_CAL_EN                     = " "0 (PFM_COMP_TRIM_CAL_EN_MAN),1 (PFM_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VDIP_COMP_TRIM_CAL_EN                    = " "0 (VDIP_COMP_TRIM_CAL_EN_MAN),1 (VDIP_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_RAMP_PEAK_TRIM_CAL_EN                = " "0 (PWM_RAMP_PEAK_TRIM_CAL_EN_MAN),1 (PWM_RAMP_PEAK_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_CAL_ENG_EN                          = " "0 (TRIM_CAL_ENG_EN_FALSE),1 (TRIM_CAL_ENG_EN_TRUE)"
    tree.end
    tree "S2_CTRL_CTLR_MISC"
      sgroup "S2_CTRL_CTLR_MISC (at 0x1177e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80177e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x177e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIS_PFM_DIR_SAMPLE                       = " "0 (DIS_PFM_DIR_SAMPLE_FALSE),1 (DIS_PFM_DIR_SAMPLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIS_VDIP_HCPFM_GATE                      = " "0 (DIS_VDIP_HCPFM_GATE_FALSE),1 (DIS_VDIP_HCPFM_GATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_PRECH_EXTEND                         = " "0 (DIS_PRECH_EXTEND_FALSE),1 (DIS_PRECH_EXTEND_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_FORCE_PWM                            = " "0 (DIS_FORCE_PWM_FALSE),1 (DIS_FORCE_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_CLAMP                                = " "0 (DIS_CLAMP_FALSE),1 (DIS_CLAMP_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PS_TIMEOUT                           = " "0 (DIS_PS_TIMEOUT_FALSE),1 (DIS_PS_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_ERRAMP_TRIM_BUF                      = " "0 (DIS_ERRAMP_TRIM_BUF_FALSE),1 (DIS_ERRAMP_TRIM_BUF_TRUE)"
    tree.end
    tree "S2_CTRL_SCRATCH_REG"
      sgroup "S2_CTRL_SCRATCH_REG (at 0x1177f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80177f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x177f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SCRATCH_7                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCRATCH_6                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCRATCH_5                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCRATCH_4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SCRATCH_3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SCRATCH_2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SCRATCH_1                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SCRATCH_0                                = " "0, 1"
    tree.end
    tree "S2_CTRL_GANG_CTL1"
      sgroup "S2_CTRL_GANG_CTL1 (at 0x117c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_CTRL_GANG_CTL2"
      sgroup "S2_CTRL_GANG_CTL2 (at 0x117c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      sgroup "S2_CTRL_SEC_ACCESS (at 0x117d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      sgroup "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      sgroup "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      sgroup "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      sgroup "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      sgroup "S2_CTRL_INT_TEST1 (at 0x117e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      sgroup "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT_TEST_VAL                  = " "0 (VREG_READY_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_READY_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_FAULT_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S2_CTRL_CTLR_TEST1"
      sgroup "S2_CTRL_CTLR_TEST1 (at 0x117e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_SEL_NORMAL_OPERATION),1 (ATEST1_SEL_ERR_AMP_OUT),2 (ATEST1_SEL_VREF_DAC),3 (ATEST1_SEL_VRAMP_PK),4 (ATEST1_SEL_VREF_RESET),5 (ATEST1_SEL_VRAMP),6 (ATEST1_SEL_VFB_DIV_PFM),7 (ATEST1_SEL_ERR_AMP_IN_MNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_SEL_NORMAL_OPERATION),1 (DTEST1_SEL_BUCK_CLK),2 (DTEST1_SEL_PS_COMP),3 (DTEST1_SEL_PULSE_SKIP_FSM),4 (DTEST1_SEL_PWM_COMP),5 (DTEST1_SEL_LO_COMP_FSM),6 (DTEST1_SEL_PFM_COMP_FSM),7 (DTEST1_SEL_MODE_FSM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S2_CTRL_CTLR_TEST2"
      sgroup "S2_CTRL_CTLR_TEST2 (at 0x117e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_SEL_NORMAL_OPERATION),1 (ATEST2_SEL_VREF_DAC_EA),2 (ATEST2_SEL_A_REG_GNDC),3 (ATEST2_SEL_VRAMP_BOT),4 (ATEST2_SEL_ERRAMP_OUT),5 (ATEST2_SEL_AVDD),6 (ATEST2_SEL_VFB_DIV_PSKIP),7 (ATEST2_SEL_VOUT_SNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_SEL_NORMAL_OPERATION),1 (DTEST2_SEL_CLK_LFRC),2 (DTEST2_SEL_INZ_CNT_DONE),3 (DTEST2_SEL_PDRV_EXTEND),4 (DTEST2_SEL_PS_EXIT),5 (DTEST2_SEL_PS_ENTER_WIN),6 (DTEST2_SEL_IPLIM_INT_MODE),7 (DTEST2_SEL_FORCE_PS_FOLDBACK)"
    tree.end
    tree "S2_CTRL_CTLR_TEST3"
      sgroup "S2_CTRL_CTLR_TEST3 (at 0x117e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST3_SEL                               = " "0 (DTEST3_SEL_NORMAL_OPERATION),1 (DTEST3_SEL_ERRAMP_DIG),2 (DTEST3_SEL_VRAMP_COMP_DIG),3 (DTEST3_SEL_PFM_COMP_CNTR),4 (DTEST3_SEL_VDIP_COMP),5 (DTEST3_SEL_TRIM_MUX_OUT),6 (DTEST3_SEL_CLAMP_ON),7 (DTEST3_SEL_RAMP_RST)"
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      sgroup "S2_CTRL_TRIM_NUM (at 0x117f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S2_CTRL_CAL_MANUAL"
      sgroup "S2_CTRL_CAL_MANUAL (at 0x117f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MAN_CAL                                  = "
    tree.end
    tree "S2_CTRL_CTL_TRIM1"
      sgroup "S2_CTRL_CTL_TRIM1 (at 0x117f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM                           = "
    tree.end
    tree "S2_CTRL_CTL_TRIM2"
      sgroup "S2_CTRL_CTL_TRIM2 (at 0x117f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM                            = "
    tree.end
    tree "S2_CTRL_CTL_TRIM4"
      sgroup "S2_CTRL_CTL_TRIM4 (at 0x117f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S2_CTRL_CTL_TRIM3"
      sgroup "S2_CTRL_CTL_TRIM3 (at 0x117f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      sgroup "S2_FREQ_REVISION1 (at 0x11900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      sgroup "S2_FREQ_REVISION2 (at 0x11901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      sgroup "S2_FREQ_PERPH_TYPE (at 0x11904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      sgroup "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      sgroup "S2_FREQ_CLK_ENABLE (at 0x11946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      sgroup "S2_FREQ_CLK_DIV (at 0x11950)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      sgroup "S2_FREQ_CLK_PHASE (at 0x11951)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      sgroup "S2_FREQ_GANG_CTL1 (at 0x119c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      sgroup "S2_FREQ_GANG_CTL2 (at 0x119c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      sgroup "S2_FREQ_SEC_ACCESS (at 0x119d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      sgroup "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      sgroup "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      sgroup "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S2_FREQ_TEST1"
      sgroup "S2_FREQ_TEST1 (at 0x119e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      sgroup "S2_PS_REVISION1 (at 0x11800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      sgroup "S2_PS_REVISION2 (at 0x11801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      sgroup "S2_PS_REVISION3 (at 0x11802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      sgroup "S2_PS_REVISION4 (at 0x11803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      sgroup "S2_PS_PERPH_TYPE (at 0x11804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      sgroup "S2_PS_PERPH_SUBTYPE (at 0x11805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_STATUS3"
      sgroup "S2_PS_STATUS3 (at 0x1180a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80180a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x180a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
    tree.end
    tree "S2_PS_STATUS4"
      sgroup "S2_PS_STATUS4 (at 0x1180b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80180b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x180b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (ECM_MISSED_DATA_FALSE),1 (ECM_MISSED_DATA_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ECM_DATA_TYPE                            = " "0 (ECM_DATA_TYPE_MEASUREMENT),1 (ECM_DATA_TYPE_REFERENCE),2 (ECM_DATA_TYPE_OFFSET),3 (ECM_DATA_TYPE_RESERVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_PRESENT_FALSE),1 (ECM_PRESENT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ECM_REQ_SW_CALIB                         = " "0 (ECM_REQ_SW_CALIB_FALSE),1 (ECM_REQ_SW_CALIB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ECM_DATA_NEGATIVE                        = " "0 (ECM_DATA_NEGATIVE_FALSE),1 (ECM_DATA_NEGATIVE_TRUE)"
    tree.end
    tree "S2_PS_PFM_FREQ_CTL"
      sgroup "S2_PS_PFM_FREQ_CTL (at 0x11844)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_FREQ_DITH_EN                         = " "0 (PFM_DITHERING_EN_FALSE),1 (PFM_DITHERING_EN_TRUE)"
    tree.end
    tree "S2_PS_PFM_FREQ_CFG"
      sgroup "S2_PS_PFM_FREQ_CFG (at 0x11845)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FREQ_DITH_NUMBIT_SEL                     = " "0 (NUMBIT_SEL_2B),1 (NUMBIT_SEL_3B)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DITH_TIMING_CTL                          = " "0 (DITH_CTL_PFM_COMP_CLK),1 (DITH_CTL_PFM_COMP_DIV4_CLK),2 (DITH_CTL_PFM_COMP_DIV32_CLK),3 (DITH_CTL_PFM_COMP_DIV128_CLK),4 (DITH_CTL_LFRC_CLK),5 (DITH_CTL_LFRC_DIV4_CLK),6 (DITH_CTL_LFRC_DIV32_CLK),7 (DITH_CTL_LFRC_DIV128_CLK)"
    tree.end
    tree "S2_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S2_PS_PWM_CURRENT_LIM_CTL (at 0x1184a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CURRENT_LIM_AUTOINT_SEL                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PWM_SEL                      = "
    tree.end
    tree "S2_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S2_PS_PFM_CURRENT_LIM_CTL (at 0x1184b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_PWM_CURRENT_LIM_EN                   = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PFM_SEL                      = "
    tree.end
    tree "S2_PS_ILIM_SS_CTL"
      sgroup "S2_PS_ILIM_SS_CTL (at 0x1184c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80184c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x184c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ILIM_SS_SEL                              = "
    tree.end
    tree "S2_PS_ISNS_THRES"
      sgroup "S2_PS_ISNS_THRES (at 0x1185a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80185a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x185a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_ENTRY_AUTO                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PS_ENTRY_PWM                             = "
    tree.end
    tree "S2_PS_QM_PS_ENTRY"
      sgroup "S2_PS_QM_PS_ENTRY (at 0x11863)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_ENTRY                           = "
    tree.end
    tree "S2_PS_SWITCH_SIZE_CTL"
      sgroup "S2_PS_SWITCH_SIZE_CTL (at 0x11870)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_MIN),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_MIN),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S2_PS_DEAD_TIME_CTRL"
      sgroup "S2_PS_DEAD_TIME_CTRL (at 0x11872)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S2_PS_BLNK_TIME_CTL"
      sgroup "S2_PS_BLNK_TIME_CTL (at 0x11873)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S2_PS_INZERO_CTL"
      sgroup "S2_PS_INZERO_CTL (at 0x11874)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S2_PS_DIG_FSM_CTL"
      sgroup "S2_PS_DIG_FSM_CTL (at 0x11875)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_LAT_DIS                              = " "0 (FSM_DISABLE_LATCH_FALSE),1 (FSM_DISABLE_LATCH_TRUE)"
    tree.end
    tree "S2_PS_CAL_EN_CTL1"
      sgroup "S2_PS_CAL_EN_CTL1 (at 0x11878)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIM_TRIM_CAL_EN                        = " "0 (IPLIM_TRIM_CAL_EN_FALSE),1 (IPLIM_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_THRES_TRIM_CAL_EN                   = " "0 (AUTO_THRES_TRIM_CAL_EN_FALSE),1 (AUTO_THRES_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INZERO_TRIM_CAL_EN                       = " "0 (INZERO_TRIM_CAL_EN_FALSE),1 (INZERO_TRIM_CAL_EN_TRUE)"
    tree.end
    tree "S2_PS_PWR_STG_MISC"
      sgroup "S2_PS_PWR_STG_MISC (at 0x1187e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0 (DUTY_EST_CLK_SEL_BIT1_FALSE),1 (DUTY_EST_CLK_SEL_BIT1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0 (DUTY_EST_CLK_SEL_BIT0_FALSE),1 (DUTY_EST_CLK_SEL_BIT0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0 (AUTO_BLOCK_THRESH_NORMAL),1 (AUTO_BLOCK_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0 (PFM_CURRENT_LIMIT_THRESH_NORMAL),1 (PFM_CURRENT_LIMIT_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (AUTO_MODE_BW_SEL_NORMAL),1 (AUTO_MODE_BW_SEL_QUARTER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0 (BYPASS_CMN_MODE_ECM_FALSE),1 (BYPASS_CMN_MODE_ECM_TRUE)"
    tree.end
    tree "S2_PS_ECM_EN_CTL"
      sgroup "S2_PS_ECM_EN_CTL (at 0x11880)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_EN_FALSE),1 (ECM_LOCAL_EN_TRUE)"
    tree.end
    tree "S2_PS_ECM_CFG_0"
      sgroup "S2_PS_ECM_CFG_0 (at 0x11881)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SENSE_SW_NTWK_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   FET_REF_SIZE_SEL                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_ADC_REF_CHOPPING                      = " "0 (EN_ADC_REF_CHOPPING_FALSE),1 (EN_ADC_REF_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_ADC_IN_CHOPPING                       = " "0 (EN_ADC_IN_CHOPPING_FALSE),1 (EN_ADC_IN_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SENSE_FILT_BW_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ADC_GAIN_SEL                             = " "0 (ADC_GAIN_SEL_GAIN_OF_2),1 (ADC_GAIN_SEL_GAIN_OF_3),2 (ADC_GAIN_SEL_GAIN_OF_3P0),3 (ADC_GAIN_SEL_GAIN_OF_4)"
    tree.end
    tree "S2_PS_ECM_CFG_1"
      sgroup "S2_PS_ECM_CFG_1 (at 0x11882)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   ECM_BIAS_CTRL                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ECM_REF_OFF_CTRL                         = " "0 (ECM_REF_OFF_CTRL_0),1 (ECM_REF_OFF_CTRL_1),2 (ECM_REF_OFF_CTRL_2),3 (ECM_REF_OFF_CTRL_3),4 (ECM_REF_OFF_CTRL_4),5 (ECM_REF_OFF_CTRL_5),6 (ECM_REF_OFF_CTRL_6),7 (ECM_REF_OFF_CTRL_7)"
    tree.end
    tree "S2_PS_ECM_DATA_LB"
      sgroup "S2_PS_ECM_DATA_LB (at 0x11884)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "S2_PS_ECM_DATA_UB"
      sgroup "S2_PS_ECM_DATA_UB (at 0x11885)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "S2_PS_SEC_ACCESS"
      sgroup "S2_PS_SEC_ACCESS (at 0x118d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      sgroup "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      sgroup "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      sgroup "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S2_PS_FORCE_FET_TEST"
      sgroup "S2_PS_FORCE_FET_TEST (at 0x118e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S2_PS_PWR_STG_TEST1"
      sgroup "S2_PS_PWR_STG_TEST1 (at 0x118e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_NORMAL),1 (ATEST1_FET_KSP1),2 (ATEST1_REF_KSP1),3 (ATEST1_ECM_OUT_CM),4 (ATEST1_A_ECM_ATEST_FORCE1),5 (ATEST1_VREF_FILT),6 (ATEST1_VREF_SNS),7 (ATEST1_FLOATING)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_MISSION_MODE),1 (DTEST1_D_AUTO_PS_THRES_COMP),2 (DTEST1_D_DC_VOUT_CLK_1),3 (DTEST1_D_PSW_DRV_SEL),4 (DTEST1_D_INZ_COMP_LOC),5 (DTEST1_D_IPLIM_COMP_LOC),6 (DTEST1_ECM_PHI1),7 (DTEST1_D_NSW_DRV_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S2_PS_PWR_STG_TEST2"
      sgroup "S2_PS_PWR_STG_TEST2 (at 0x118e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_MISSION_MODE),1 (ATEST2_FET_KSP2),2 (ATEST2_REF_KSP2),3 (ATEST2_ECM_VBIAS),4 (ATEST2_A_ECM_ATEST_FORCE2),5 (ATEST2_VSW_FILT),6 (ATEST2_VSW_SNS),7 (ATEST2_SPARE)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_MISSION_MODE),1 (DTEST2_D_END_MIN_PON),2 (DTEST2_D_DC_COMP_OUT),3 (DTEST2_D_PFM_ENTRY_BUF),4 (DTEST2_D_INZ_COMP_EXTEND),5 (DTEST2_D_PGATE_BLNK),6 (DTEST2_ECM_PHI2),7 (DTEST2_D_PSK_ENTRY_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIM_TEST_CTRL                          = " "0 (IPLIM_TEST_MODE_CTRL_RESERVED_0),1 (IPLIM_TEST_MODE_CTRL_RESERVED_1),2 (IPLIM_TEST_MODE_CTRL_RESERVED_2),3 (IPLIM_TEST_MODE_CTRL_RESERVED_3)"
    tree.end
    tree "S2_PS_PWR_STG_TEST3"
      sgroup "S2_PS_PWR_STG_TEST3 (at 0x118e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST3_SEL                               = " "0 (DTEST3_MISSION_MODE),1 (DTEST3_D_D2A_ECM_DTEST_DEC_0_D_D2A_ECM_ADC_INPUT_POLARITY),2 (DTEST3_D_D2A_ECM_DTEST_DEC_2_D_D2A_ECM_ADC_INPUT_MUX_CTRL_1),3 (DTEST3_D_D2A_ECM_DTEST_DEC_4_D_CHOP_SYNC),4 (DTEST3_D_D2A_ECM_DTEST_DEC_6_D_CAL_STROBE),5 (DTEST3_CAL_MUX_FILT_OUT),6 (DTEST3_ECM_COMP_P),7 (DTEST3_ECM_COMP_N)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST4_SEL                               = " "0 (DTEST4_MISSION_MODE),1 (DTEST4_D_D2A_ECM_DTEST_DEC_1_D_D2A_ECM_ADC_INPUT_MUX_CTRL_0),2 (DTEST4_D_D2A_ECM_DTEST_DEC_3_D_D2A_ECM_ADC_INPUT_MUX_CTRL_2),3 (DTEST4_D_D2A_ECM_DTEST_DEC_5_D_GLOBAL_EN),4 (DTEST4_D_D2A_ECM_DTEST_DEC_7_D_STROBE),5 (DTEST4_SPARE),6 (DTEST4_ECM_ADC_INPUT_POLARITY),7 (DTEST4_D_ADC_CLR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SENSE                                 = " "0 (EN_SENSE_FALSE),1 (EN_SENSE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_ADC                                   = " "0 (EN_ADC_FALSE),1 (EN_ADC_TRUE)"
    tree.end
    tree "S2_PS_PWR_STG_TEST4"
      sgroup "S2_PS_PWR_STG_TEST4 (at 0x118e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_TEST_EN                              = " "0 (ECM_TEST_EN_FALSE),1 (ECM_TEST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ECM_INPUT_MUX_CTRL                       = " "0 (ECM_INPUT_MUX_CTRL_0),1 (ECM_INPUT_MUX_CTRL_1),2 (ECM_INPUT_MUX_CTRL_2),3 (ECM_INPUT_MUX_CTRL_3),4 (ECM_INPUT_MUX_CTRL_4),5 (ECM_INPUT_MUX_CTRL_5),6 (ECM_INPUT_MUX_CTRL_6),7 (ECM_INPUT_MUX_CTRL_7)"
    tree.end
    tree "S2_PS_TRIM_NUM"
      sgroup "S2_PS_TRIM_NUM (at 0x118f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S2_PS_PS_TRIM1"
      sgroup "S2_PS_PS_TRIM1 (at 0x118f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IPLIM_TRIM                               = "
    tree.end
    tree "S2_PS_PS_TRIM2"
      sgroup "S2_PS_PS_TRIM2 (at 0x118f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S2_PS_PS_TRIM3"
      sgroup "S2_PS_PS_TRIM3 (at 0x118f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AUTO_THRS_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      sgroup "S3_CTRL_REVISION1 (at 0x11a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      sgroup "S3_CTRL_REVISION2 (at 0x11a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      sgroup "S3_CTRL_REVISION3 (at 0x11a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      sgroup "S3_CTRL_REVISION4 (at 0x11a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      sgroup "S3_CTRL_PERPH_TYPE (at 0x11a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      sgroup "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS1"
      sgroup "S3_CTRL_STATUS1 (at 0x11a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (VREG_ERR_FALSE),1 (VREG_ERR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_FAULT),1 (FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_TRUE                                  = " "0 (PS_TRUE_FALSE),1 (PS_TRUE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIME_SPEND_PWM_READY                     = " "0 (TIME_SPEND_PWM_READY_FALSE),1 (TIME_SPEND_PWM_READY_TRUE)"
    tree.end
    tree "S3_CTRL_STATUS2"
      sgroup "S3_CTRL_STATUS2 (at 0x11a09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIME_SPEND_PWM                           = "
    tree.end
    tree "S3_CTRL_STATUS3"
      sgroup "S3_CTRL_STATUS3 (at 0x11a0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   CAL_FAULT                                = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      sgroup "S3_CTRL_INT_RT_STS (at 0x11a10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (VREG_FAULT_FALSE),1 (VREG_FAULT_TRUE)"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      sgroup "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      sgroup "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      sgroup "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      sgroup "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      sgroup "S3_CTRL_INT_EN_SET (at 0x11a15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      sgroup "S3_CTRL_INT_EN_CLR (at 0x11a16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      sgroup "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      sgroup "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      sgroup "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      sgroup "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S3_CTRL_VSET_LB"
      sgroup "S3_CTRL_VSET_LB (at 0x11a40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "S3_CTRL_VSET_UB"
      sgroup "S3_CTRL_VSET_UB (at 0x11a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "S3_CTRL_VSET_VALID_LB"
      sgroup "S3_CTRL_VSET_VALID_LB (at 0x11a42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID_LB                            = "
    tree.end
    tree "S3_CTRL_VSET_VALID_UB"
      sgroup "S3_CTRL_VSET_VALID_UB (at 0x11a43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "S3_CTRL_PFM_CTL"
      sgroup "S3_CTRL_PFM_CTL (at 0x11a44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S3_CTRL_MODE_CTL1"
      sgroup "S3_CTRL_MODE_CTL1 (at 0x11a45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S3_CTRL_EN_CTL"
      sgroup "S3_CTRL_EN_CTL (at 0x11a46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S3_CTRL_FOLLOW_HWEN"
      sgroup "S3_CTRL_FOLLOW_HWEN (at 0x11a47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_AWAKE_CFG                         = " "0 (FOLLOW_AWAKE_CFG_FALSE),1 (FOLLOW_AWAKE_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HWEN2_CFG                         = " "0 (FOLLOW_HWEN2_CFG_FALSE),1 (FOLLOW_HWEN2_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_HWEN1_CFG                         = " "0 (FOLLOW_HWEN1_CFG_FALSE),1 (FOLLOW_HWEN1_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_HWEN0_CFG                         = " "0 (FOLLOW_HWEN0_CFG_FALSE),1 (FOLLOW_HWEN0_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HWEN2                          = " "0 (EN_FOLLOW_HWEN2_FALSE),1 (EN_FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HWEN1                          = " "0 (EN_FOLLOW_HWEN1_FALSE),1 (EN_FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HWEN0                          = " "0 (EN_FOLLOW_HWEN0_FALSE),1 (EN_FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S3_CTRL_PD_CTL"
      sgroup "S3_CTRL_PD_CTL (at 0x11a48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ENABLE_FALSE),1 (STRONG_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_ENABLE_FALSE),1 (WEAK_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_PFM_FALSE),1 (WEAK_PD_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_PWM_FALSE),1 (WEAK_PD_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAK_PD_EN_FALSE),1 (LEAK_PD_EN_TRUE)"
    tree.end
    tree "S3_CTRL_MODE_CTL2"
      sgroup "S3_CTRL_MODE_CTL2 (at 0x11a49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S3_CTRL_RETENTION_CTL1"
      sgroup "S3_CTRL_RETENTION_CTL1 (at 0x11a4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_P1                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_M1                            = "
    tree.end
    tree "S3_CTRL_RETENTION_CTL2"
      sgroup "S3_CTRL_RETENTION_CTL2 (at 0x11a4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_X2                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_DIV2                          = "
    tree.end
    tree "S3_CTRL_RETENTION_STS1"
      sgroup "S3_CTRL_RETENTION_STS1 (at 0x11a4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_PERIOD                               = "
    tree.end
    tree "S3_CTRL_RETENTION_STS2"
      sgroup "S3_CTRL_RETENTION_STS2 (at 0x11a4d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a4d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_COUNT                                = "
    tree.end
    tree "S3_CTRL_RETENTION_STS3"
      sgroup "S3_CTRL_RETENTION_STS3 (at 0x11a4e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a4e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES                               = "
    tree.end
    tree "S3_CTRL_FREQ_CTL"
      sgroup "S3_CTRL_FREQ_CTL (at 0x11a50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S3_CTRL_COMP_CAP_C1_C2_CTL"
      sgroup "S3_CTRL_COMP_CAP_C1_C2_CTL (at 0x11a51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   C1_CTRL                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   C2_CTRL                                  = " "0 (C2_CAP_0P0_PF),1 (C2_CAP_0P2_PF),2 (C2_CAP_0P4_PF),3 (C2_CAP_0P6_PF)"
    tree.end
    tree "S3_CTRL_COMP_CAP_C3_CTL"
      sgroup "S3_CTRL_COMP_CAP_C3_CTL (at 0x11a52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   C3_CTRL                                  = "
    tree.end
    tree "S3_CTRL_R1_R2_CTL"
      sgroup "S3_CTRL_R1_R2_CTL (at 0x11a53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   R1_CTL                                   = "
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   R2_CTL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_BUCK_SNS_CTL"
      sgroup "S3_CTRL_BUCK_SNS_CTL (at 0x11a54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SNS_SEL                                  = " "0 (SNS_SEL_0_VREG_SX),1 (SNS_SEL_1_VIN_LDO)"
    tree.end
    tree "S3_CTRL_RAMP_AMPLITUDE_CTL"
      sgroup "S3_CTRL_RAMP_AMPLITUDE_CTL (at 0x11a56)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_FREQ_CTL_LOGIC                    = " "0 (FOLLOW_FREQ_CTL_LOGIC_0_RAMP_AMPLITUDE),1 (FOLLOW_FREQ_CTL_LOGIC_1_FREQ_CTL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMPAMPLITUDE                        = "
    tree.end
    tree "S3_CTRL_DMAX_CTL"
      sgroup "S3_CTRL_DMAX_CTL (at 0x11a58)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_CTL"
      sgroup "S3_CTRL_PULSE_SKIP_CTL (at 0x11a59)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_4CYCLE),1 (PS_TIME_HYST_8CYCLE),2 (PS_TIME_HYST_16CYCLE),3 (PS_TIME_HYST_32CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S3_CTRL_PS_THRES_ERRAMP"
      sgroup "S3_CTRL_PS_THRES_ERRAMP (at 0x11a5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ERRAMP                           = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_VRST_RANGE                            = " "0 (PS_VRST_RANGE_LOW),1 (PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VRST                                  = " "0 (PS_VRST_0MV),1 (PS_VRST_VOUTDIV30),2 (PS_VRST_VOUTDIV20),3 (PS_VRST_VOUTDIV15),4 (PS_VRST_VOUTDIV12),5 (PS_VRST_VOUTDIV10),6 (PS_VRST_VOUTDIV9),7 (PS_VRST_VOUTDIV8)"
    tree.end
    tree "S3_CTRL_AUTO_MODE_CTL"
      sgroup "S3_CTRL_AUTO_MODE_CTL (at 0x11a5b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_32CYCLES)"
    tree.end
    tree "S3_CTRL_INZERO_COUNT_CTL"
      sgroup "S3_CTRL_INZERO_COUNT_CTL (at 0x11a5c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PFM_COUNT_CTL"
      sgroup "S3_CTRL_PFM_COUNT_CTL (at 0x11a5d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PS_THRES_ILOAD"
      sgroup "S3_CTRL_PS_THRES_ILOAD (at 0x11a5e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ILOAD                            = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_METHOD_STEPPER                        = " "0 (PS_METHOD_STEPPER_ILOAD),1 (PS_METHOD_STEPPER_WINDOW)"
    tree.end
    tree "S3_CTRL_STEPPER_SS_CTL"
      sgroup "S3_CTRL_STEPPER_SS_CTL (at 0x11a60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_STEPPER_DELAY                         = " "0 (STEPPER_SS_2_CLK_CYCLES),1 (STEPPER_SS_4_CLK_CYCLES),2 (STEPPER_SS_8_CLK_CYCLES),3 (STEPPER_SS_16_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_STEPPER_VS_CTL"
      sgroup "S3_CTRL_STEPPER_VS_CTL (at 0x11a61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VS_STEPPER_DELAY                         = " "0 (STEPPER_VS_2_CLK_CYCLES),1 (STEPPER_VS_4_CLK_CYCLES),2 (STEPPER_VS_8_CLK_CYCLES),3 (STEPPER_VS_16_CLK_CYCLES)"
    tree.end
    tree "S3_CTRL_QM_PS_EXIT"
      sgroup "S3_CTRL_QM_PS_EXIT (at 0x11a63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QM_MODE                                  = " "0 (QM_MODE_FORCE_PFM_DITHER_ENABLED),1 (QM_MODE_FORCED_PWM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QM_FOLLOW                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QM_PS_METHOD                             = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QM_PS_VRST_RANGE                         = " "0 (QM_PS_VRST_RANGE_LOW),1 (QM_PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   QM_PS_VRST                               = " "0 (QM_PS_VRST_0MV),1 (QM_PS_VRST_VOUTDIV30),2 (QM_PS_VRST_VOUTDIV20),3 (QM_PS_VRST_VOUTDIV15),4 (QM_PS_VRST_VOUTDIV12),5 (QM_PS_VRST_VOUTDIV10),6 (QM_PS_VRST_VOUTDIV9),7 (QM_PS_VRST_VOUTDIV8)"
    tree.end
    tree "S3_CTRL_OCP"
      sgroup "S3_CTRL_OCP (at 0x11a66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_LATCH_EN                             = " "0 (OCP_LATCH_EN_FALSE),1 (OCP_LATCH_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_FOLDBACK_EN                         = " "0 (FORCE_FOLDBACK_FALSE),1 (FORCE_FOLDBACK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   INZERO_WAIT_OCP_TIMER                    = " "0 (INZERO_WAIT_40US_OCP_TIMER_320US),1 (INZERO_WAIT_80US_OCP_TIMER_640US),2 (INZERO_WAIT_160US_OCP_TIMER_1280_US),3 (INZERO_WAIT_160US_OCP_TIMER_1280US)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_EN_FALSE),1 (OCP_GLOBAL_BROADCAST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLEAR                         = " "0 (OCP_STATUS_CLEAR_FALSE),1 (OCP_STATUS_CLEAR_TRUE)"
    tree.end
    tree "S3_CTRL_ULS_VSET_LB"
      sgroup "S3_CTRL_ULS_VSET_LB (at 0x11a68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "S3_CTRL_ULS_VSET_UB"
      sgroup "S3_CTRL_ULS_VSET_UB (at 0x11a69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "S3_CTRL_STATUS_DEB_CTL"
      sgroup "S3_CTRL_STATUS_DEB_CTL (at 0x11a70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_0_LFRC_DIV2),1 (READY_DEB_1_LFRC_DIV4),2 (READY_DEB_2_LFRC_DIV8),3 (READY_DEB_3_LFRC_DIV16)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_0_LFRC_DIV2),1 (ERROR_DEB_1_LFRC_DIV4),2 (ERROR_DEB_2_LFRC_DIV8),3 (ERROR_DEB_3_LFRC_DIV16)"
    tree.end
    tree "S3_CTRL_CAL_TIMER_CTL"
      sgroup "S3_CTRL_CAL_TIMER_CTL (at 0x11a71)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER                                = "
    tree.end
    tree "S3_CTRL_CAL_START"
      sgroup "S3_CTRL_CAL_START (at 0x11a72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQ_WR_PULSE                         = " "0 (CAL_REQ_WR_PULSE_FALSE),1 (CAL_REQ_WR_PULSE_TRUE)"
    tree.end
    tree "S3_CTRL_CAL_TRIM1"
      sgroup "S3_CTRL_CAL_TRIM1 (at 0x11a73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERR_AMP_TRIM_AUTO                        = "
    tree.end
    tree "S3_CTRL_CAL_TRIM2"
      sgroup "S3_CTRL_CAL_TRIM2 (at 0x11a74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM_AUTO                      = "
    tree.end
    tree "S3_CTRL_CAL_TRIM3"
      sgroup "S3_CTRL_CAL_TRIM3 (at 0x11a75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM_AUTO                       = "
    tree.end
    tree "S3_CTRL_CAL_TRIM4"
      sgroup "S3_CTRL_CAL_TRIM4 (at 0x11a76)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM_AUTO                      = "
    tree.end
    tree "S3_CTRL_CAL_TRIM5"
      sgroup "S3_CTRL_CAL_TRIM5 (at 0x11a77)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM_AUTO                  = "
    tree.end
    tree "S3_CTRL_CAL_TRIM_EN_CTL"
      sgroup "S3_CTRL_CAL_TRIM_EN_CTL (at 0x11a78)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ERR_AMP_TRIM_CAL_EN                      = " "0 (reserved),1 (ERR_AMP_TRIM_CAL_EN_MAN),2 (reserved),3 (ERR_AMP_TRIM_CAL_EN_AUTO)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PWM_THRES_TRIM_CAL_EN                    = " "0 (PWM_THRES_TRIM_CAL_EN_MAN),1 (PWM_THRES_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_TRIM_CAL_EN                     = " "0 (PFM_COMP_TRIM_CAL_EN_MAN),1 (PFM_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VDIP_COMP_TRIM_CAL_EN                    = " "0 (VDIP_COMP_TRIM_CAL_EN_MAN),1 (VDIP_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_RAMP_PEAK_TRIM_CAL_EN                = " "0 (PWM_RAMP_PEAK_TRIM_CAL_EN_MAN),1 (PWM_RAMP_PEAK_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_CAL_ENG_EN                          = " "0 (TRIM_CAL_ENG_EN_FALSE),1 (TRIM_CAL_ENG_EN_TRUE)"
    tree.end
    tree "S3_CTRL_CTLR_MISC"
      sgroup "S3_CTRL_CTLR_MISC (at 0x11a7e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a7e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIS_PFM_DIR_SAMPLE                       = " "0 (DIS_PFM_DIR_SAMPLE_FALSE),1 (DIS_PFM_DIR_SAMPLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIS_VDIP_HCPFM_GATE                      = " "0 (DIS_VDIP_HCPFM_GATE_FALSE),1 (DIS_VDIP_HCPFM_GATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_PRECH_EXTEND                         = " "0 (DIS_PRECH_EXTEND_FALSE),1 (DIS_PRECH_EXTEND_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_FORCE_PWM                            = " "0 (DIS_FORCE_PWM_FALSE),1 (DIS_FORCE_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_CLAMP                                = " "0 (DIS_CLAMP_FALSE),1 (DIS_CLAMP_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PS_TIMEOUT                           = " "0 (DIS_PS_TIMEOUT_FALSE),1 (DIS_PS_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_ERRAMP_TRIM_BUF                      = " "0 (DIS_ERRAMP_TRIM_BUF_FALSE),1 (DIS_ERRAMP_TRIM_BUF_TRUE)"
    tree.end
    tree "S3_CTRL_SCRATCH_REG"
      sgroup "S3_CTRL_SCRATCH_REG (at 0x11a7f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a7f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a7f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SCRATCH_7                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCRATCH_6                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCRATCH_5                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCRATCH_4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SCRATCH_3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SCRATCH_2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SCRATCH_1                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SCRATCH_0                                = " "0, 1"
    tree.end
    tree "S3_CTRL_GANG_CTL1"
      sgroup "S3_CTRL_GANG_CTL1 (at 0x11ac0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ac00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ac00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_CTRL_GANG_CTL2"
      sgroup "S3_CTRL_GANG_CTL2 (at 0x11ac1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ac10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ac10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S3_CTRL_SEC_ACCESS"
      sgroup "S3_CTRL_SEC_ACCESS (at 0x11ad0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      sgroup "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      sgroup "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      sgroup "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      sgroup "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      sgroup "S3_CTRL_INT_TEST1 (at 0x11ae0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      sgroup "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT_TEST_VAL                  = " "0 (VREG_READY_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_READY_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_FAULT_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S3_CTRL_CTLR_TEST1"
      sgroup "S3_CTRL_CTLR_TEST1 (at 0x11ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_SEL_NORMAL_OPERATION),1 (ATEST1_SEL_ERR_AMP_OUT),2 (ATEST1_SEL_VREF_DAC),3 (ATEST1_SEL_VRAMP_PK),4 (ATEST1_SEL_VREF_RESET),5 (ATEST1_SEL_VRAMP),6 (ATEST1_SEL_VFB_DIV_PFM),7 (ATEST1_SEL_ERR_AMP_IN_MNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_SEL_NORMAL_OPERATION),1 (DTEST1_SEL_BUCK_CLK),2 (DTEST1_SEL_PS_COMP),3 (DTEST1_SEL_PULSE_SKIP_FSM),4 (DTEST1_SEL_PWM_COMP),5 (DTEST1_SEL_LO_COMP_FSM),6 (DTEST1_SEL_PFM_COMP_FSM),7 (DTEST1_SEL_MODE_FSM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_CTRL_CTLR_TEST2"
      sgroup "S3_CTRL_CTLR_TEST2 (at 0x11ae3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_SEL_NORMAL_OPERATION),1 (ATEST2_SEL_VREF_DAC_EA),2 (ATEST2_SEL_A_REG_GNDC),3 (ATEST2_SEL_VRAMP_BOT),4 (ATEST2_SEL_ERRAMP_OUT),5 (ATEST2_SEL_AVDD),6 (ATEST2_SEL_VFB_DIV_PSKIP),7 (ATEST2_SEL_VOUT_SNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_SEL_NORMAL_OPERATION),1 (DTEST2_SEL_CLK_LFRC),2 (DTEST2_SEL_INZ_CNT_DONE),3 (DTEST2_SEL_PDRV_EXTEND),4 (DTEST2_SEL_PS_EXIT),5 (DTEST2_SEL_PS_ENTER_WIN),6 (DTEST2_SEL_IPLIM_INT_MODE),7 (DTEST2_SEL_FORCE_PS_FOLDBACK)"
    tree.end
    tree "S3_CTRL_CTLR_TEST3"
      sgroup "S3_CTRL_CTLR_TEST3 (at 0x11ae4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST3_SEL                               = " "0 (DTEST3_SEL_NORMAL_OPERATION),1 (DTEST3_SEL_ERRAMP_DIG),2 (DTEST3_SEL_VRAMP_COMP_DIG),3 (DTEST3_SEL_PFM_COMP_CNTR),4 (DTEST3_SEL_VDIP_COMP),5 (DTEST3_SEL_TRIM_MUX_OUT),6 (DTEST3_SEL_CLAMP_ON),7 (DTEST3_SEL_RAMP_RST)"
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      sgroup "S3_CTRL_TRIM_NUM (at 0x11af0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_CTRL_CAL_MANUAL"
      sgroup "S3_CTRL_CAL_MANUAL (at 0x11af1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MAN_CAL                                  = "
    tree.end
    tree "S3_CTRL_CTL_TRIM1"
      sgroup "S3_CTRL_CTL_TRIM1 (at 0x11af2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM                           = "
    tree.end
    tree "S3_CTRL_CTL_TRIM2"
      sgroup "S3_CTRL_CTL_TRIM2 (at 0x11af3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM                            = "
    tree.end
    tree "S3_CTRL_CTL_TRIM4"
      sgroup "S3_CTRL_CTL_TRIM4 (at 0x11af4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S3_CTRL_CTL_TRIM3"
      sgroup "S3_CTRL_CTL_TRIM3 (at 0x11af5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      sgroup "S3_FREQ_REVISION1 (at 0x11c00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      sgroup "S3_FREQ_REVISION2 (at 0x11c01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      sgroup "S3_FREQ_PERPH_TYPE (at 0x11c04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      sgroup "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      sgroup "S3_FREQ_CLK_ENABLE (at 0x11c46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      sgroup "S3_FREQ_CLK_DIV (at 0x11c50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      sgroup "S3_FREQ_CLK_PHASE (at 0x11c51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      sgroup "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      sgroup "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      sgroup "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      sgroup "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      sgroup "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      sgroup "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S3_FREQ_TEST1"
      sgroup "S3_FREQ_TEST1 (at 0x11ce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      sgroup "S3_PS_REVISION1 (at 0x11b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      sgroup "S3_PS_REVISION2 (at 0x11b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      sgroup "S3_PS_REVISION3 (at 0x11b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      sgroup "S3_PS_REVISION4 (at 0x11b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      sgroup "S3_PS_PERPH_TYPE (at 0x11b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      sgroup "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_STATUS3"
      sgroup "S3_PS_STATUS3 (at 0x11b0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
    tree.end
    tree "S3_PS_STATUS4"
      sgroup "S3_PS_STATUS4 (at 0x11b0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (ECM_MISSED_DATA_FALSE),1 (ECM_MISSED_DATA_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ECM_DATA_TYPE                            = " "0 (ECM_DATA_TYPE_MEASUREMENT),1 (ECM_DATA_TYPE_REFERENCE),2 (ECM_DATA_TYPE_OFFSET),3 (ECM_DATA_TYPE_RESERVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_PRESENT_FALSE),1 (ECM_PRESENT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ECM_REQ_SW_CALIB                         = " "0 (ECM_REQ_SW_CALIB_FALSE),1 (ECM_REQ_SW_CALIB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ECM_DATA_NEGATIVE                        = " "0 (ECM_DATA_NEGATIVE_FALSE),1 (ECM_DATA_NEGATIVE_TRUE)"
    tree.end
    tree "S3_PS_PFM_FREQ_CTL"
      sgroup "S3_PS_PFM_FREQ_CTL (at 0x11b44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_FREQ_DITH_EN                         = " "0 (PFM_DITHERING_EN_FALSE),1 (PFM_DITHERING_EN_TRUE)"
    tree.end
    tree "S3_PS_PFM_FREQ_CFG"
      sgroup "S3_PS_PFM_FREQ_CFG (at 0x11b45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FREQ_DITH_NUMBIT_SEL                     = " "0 (NUMBIT_SEL_2B),1 (NUMBIT_SEL_3B)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DITH_TIMING_CTL                          = " "0 (DITH_CTL_PFM_COMP_CLK),1 (DITH_CTL_PFM_COMP_DIV4_CLK),2 (DITH_CTL_PFM_COMP_DIV32_CLK),3 (DITH_CTL_PFM_COMP_DIV128_CLK),4 (DITH_CTL_LFRC_CLK),5 (DITH_CTL_LFRC_DIV4_CLK),6 (DITH_CTL_LFRC_DIV32_CLK),7 (DITH_CTL_LFRC_DIV128_CLK)"
    tree.end
    tree "S3_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PWM_CURRENT_LIM_CTL (at 0x11b4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CURRENT_LIM_AUTOINT_SEL                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PWM_SEL                      = "
    tree.end
    tree "S3_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PFM_CURRENT_LIM_CTL (at 0x11b4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_PWM_CURRENT_LIM_EN                   = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PFM_SEL                      = "
    tree.end
    tree "S3_PS_ILIM_SS_CTL"
      sgroup "S3_PS_ILIM_SS_CTL (at 0x11b4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ILIM_SS_SEL                              = "
    tree.end
    tree "S3_PS_ISNS_THRES"
      sgroup "S3_PS_ISNS_THRES (at 0x11b5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_ENTRY_AUTO                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PS_ENTRY_PWM                             = "
    tree.end
    tree "S3_PS_QM_PS_ENTRY"
      sgroup "S3_PS_QM_PS_ENTRY (at 0x11b63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_ENTRY                           = "
    tree.end
    tree "S3_PS_SWITCH_SIZE_CTL"
      sgroup "S3_PS_SWITCH_SIZE_CTL (at 0x11b70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_MIN),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_MIN),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL"
      sgroup "S3_PS_DEAD_TIME_CTRL (at 0x11b72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S3_PS_BLNK_TIME_CTL"
      sgroup "S3_PS_BLNK_TIME_CTL (at 0x11b73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S3_PS_INZERO_CTL"
      sgroup "S3_PS_INZERO_CTL (at 0x11b74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S3_PS_DIG_FSM_CTL"
      sgroup "S3_PS_DIG_FSM_CTL (at 0x11b75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_LAT_DIS                              = " "0 (FSM_DISABLE_LATCH_FALSE),1 (FSM_DISABLE_LATCH_TRUE)"
    tree.end
    tree "S3_PS_CAL_EN_CTL1"
      sgroup "S3_PS_CAL_EN_CTL1 (at 0x11b78)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIM_TRIM_CAL_EN                        = " "0 (IPLIM_TRIM_CAL_EN_FALSE),1 (IPLIM_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_THRES_TRIM_CAL_EN                   = " "0 (AUTO_THRES_TRIM_CAL_EN_FALSE),1 (AUTO_THRES_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INZERO_TRIM_CAL_EN                       = " "0 (INZERO_TRIM_CAL_EN_FALSE),1 (INZERO_TRIM_CAL_EN_TRUE)"
    tree.end
    tree "S3_PS_PWR_STG_MISC"
      sgroup "S3_PS_PWR_STG_MISC (at 0x11b7e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b7e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0 (DUTY_EST_CLK_SEL_BIT1_FALSE),1 (DUTY_EST_CLK_SEL_BIT1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0 (DUTY_EST_CLK_SEL_BIT0_FALSE),1 (DUTY_EST_CLK_SEL_BIT0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0 (AUTO_BLOCK_THRESH_NORMAL),1 (AUTO_BLOCK_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0 (PFM_CURRENT_LIMIT_THRESH_NORMAL),1 (PFM_CURRENT_LIMIT_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (AUTO_MODE_BW_SEL_NORMAL),1 (AUTO_MODE_BW_SEL_QUARTER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0 (BYPASS_CMN_MODE_ECM_FALSE),1 (BYPASS_CMN_MODE_ECM_TRUE)"
    tree.end
    tree "S3_PS_ECM_EN_CTL"
      sgroup "S3_PS_ECM_EN_CTL (at 0x11b80)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_EN_FALSE),1 (ECM_LOCAL_EN_TRUE)"
    tree.end
    tree "S3_PS_ECM_CFG_0"
      sgroup "S3_PS_ECM_CFG_0 (at 0x11b81)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SENSE_SW_NTWK_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   FET_REF_SIZE_SEL                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_ADC_REF_CHOPPING                      = " "0 (EN_ADC_REF_CHOPPING_FALSE),1 (EN_ADC_REF_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_ADC_IN_CHOPPING                       = " "0 (EN_ADC_IN_CHOPPING_FALSE),1 (EN_ADC_IN_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SENSE_FILT_BW_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ADC_GAIN_SEL                             = " "0 (ADC_GAIN_SEL_GAIN_OF_2),1 (ADC_GAIN_SEL_GAIN_OF_3),2 (ADC_GAIN_SEL_GAIN_OF_3P0),3 (ADC_GAIN_SEL_GAIN_OF_4)"
    tree.end
    tree "S3_PS_ECM_CFG_1"
      sgroup "S3_PS_ECM_CFG_1 (at 0x11b82)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   ECM_BIAS_CTRL                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ECM_REF_OFF_CTRL                         = " "0 (ECM_REF_OFF_CTRL_0),1 (ECM_REF_OFF_CTRL_1),2 (ECM_REF_OFF_CTRL_2),3 (ECM_REF_OFF_CTRL_3),4 (ECM_REF_OFF_CTRL_4),5 (ECM_REF_OFF_CTRL_5),6 (ECM_REF_OFF_CTRL_6),7 (ECM_REF_OFF_CTRL_7)"
    tree.end
    tree "S3_PS_ECM_DATA_LB"
      sgroup "S3_PS_ECM_DATA_LB (at 0x11b84)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "S3_PS_ECM_DATA_UB"
      sgroup "S3_PS_ECM_DATA_UB (at 0x11b85)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "S3_PS_SEC_ACCESS"
      sgroup "S3_PS_SEC_ACCESS (at 0x11bd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      sgroup "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      sgroup "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      sgroup "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S3_PS_FORCE_FET_TEST"
      sgroup "S3_PS_FORCE_FET_TEST (at 0x11be3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S3_PS_PWR_STG_TEST1"
      sgroup "S3_PS_PWR_STG_TEST1 (at 0x11be4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_NORMAL),1 (ATEST1_FET_KSP1),2 (ATEST1_REF_KSP1),3 (ATEST1_ECM_OUT_CM),4 (ATEST1_A_ECM_ATEST_FORCE1),5 (ATEST1_VREF_FILT),6 (ATEST1_VREF_SNS),7 (ATEST1_FLOATING)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_MISSION_MODE),1 (DTEST1_D_AUTO_PS_THRES_COMP),2 (DTEST1_D_DC_VOUT_CLK_1),3 (DTEST1_D_PSW_DRV_SEL),4 (DTEST1_D_INZ_COMP_LOC),5 (DTEST1_D_IPLIM_COMP_LOC),6 (DTEST1_ECM_PHI1),7 (DTEST1_D_NSW_DRV_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S3_PS_PWR_STG_TEST2"
      sgroup "S3_PS_PWR_STG_TEST2 (at 0x11be5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_MISSION_MODE),1 (ATEST2_FET_KSP2),2 (ATEST2_REF_KSP2),3 (ATEST2_ECM_VBIAS),4 (ATEST2_A_ECM_ATEST_FORCE2),5 (ATEST2_VSW_FILT),6 (ATEST2_VSW_SNS),7 (ATEST2_SPARE)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_MISSION_MODE),1 (DTEST2_D_END_MIN_PON),2 (DTEST2_D_DC_COMP_OUT),3 (DTEST2_D_PFM_ENTRY_BUF),4 (DTEST2_D_INZ_COMP_EXTEND),5 (DTEST2_D_PGATE_BLNK),6 (DTEST2_ECM_PHI2),7 (DTEST2_D_PSK_ENTRY_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIM_TEST_CTRL                          = " "0 (IPLIM_TEST_MODE_CTRL_RESERVED_0),1 (IPLIM_TEST_MODE_CTRL_RESERVED_1),2 (IPLIM_TEST_MODE_CTRL_RESERVED_2),3 (IPLIM_TEST_MODE_CTRL_RESERVED_3)"
    tree.end
    tree "S3_PS_PWR_STG_TEST3"
      sgroup "S3_PS_PWR_STG_TEST3 (at 0x11be6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST3_SEL                               = " "0 (DTEST3_MISSION_MODE),1 (DTEST3_D_D2A_ECM_DTEST_DEC_0_D_D2A_ECM_ADC_INPUT_POLARITY),2 (DTEST3_D_D2A_ECM_DTEST_DEC_2_D_D2A_ECM_ADC_INPUT_MUX_CTRL_1),3 (DTEST3_D_D2A_ECM_DTEST_DEC_4_D_CHOP_SYNC),4 (DTEST3_D_D2A_ECM_DTEST_DEC_6_D_CAL_STROBE),5 (DTEST3_CAL_MUX_FILT_OUT),6 (DTEST3_ECM_COMP_P),7 (DTEST3_ECM_COMP_N)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST4_SEL                               = " "0 (DTEST4_MISSION_MODE),1 (DTEST4_D_D2A_ECM_DTEST_DEC_1_D_D2A_ECM_ADC_INPUT_MUX_CTRL_0),2 (DTEST4_D_D2A_ECM_DTEST_DEC_3_D_D2A_ECM_ADC_INPUT_MUX_CTRL_2),3 (DTEST4_D_D2A_ECM_DTEST_DEC_5_D_GLOBAL_EN),4 (DTEST4_D_D2A_ECM_DTEST_DEC_7_D_STROBE),5 (DTEST4_SPARE),6 (DTEST4_ECM_ADC_INPUT_POLARITY),7 (DTEST4_D_ADC_CLR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SENSE                                 = " "0 (EN_SENSE_FALSE),1 (EN_SENSE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_ADC                                   = " "0 (EN_ADC_FALSE),1 (EN_ADC_TRUE)"
    tree.end
    tree "S3_PS_PWR_STG_TEST4"
      sgroup "S3_PS_PWR_STG_TEST4 (at 0x11be7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_TEST_EN                              = " "0 (ECM_TEST_EN_FALSE),1 (ECM_TEST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ECM_INPUT_MUX_CTRL                       = " "0 (ECM_INPUT_MUX_CTRL_0),1 (ECM_INPUT_MUX_CTRL_1),2 (ECM_INPUT_MUX_CTRL_2),3 (ECM_INPUT_MUX_CTRL_3),4 (ECM_INPUT_MUX_CTRL_4),5 (ECM_INPUT_MUX_CTRL_5),6 (ECM_INPUT_MUX_CTRL_6),7 (ECM_INPUT_MUX_CTRL_7)"
    tree.end
    tree "S3_PS_TRIM_NUM"
      sgroup "S3_PS_TRIM_NUM (at 0x11bf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_PS_PS_TRIM1"
      sgroup "S3_PS_PS_TRIM1 (at 0x11bf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IPLIM_TRIM                               = "
    tree.end
    tree "S3_PS_PS_TRIM2"
      sgroup "S3_PS_PS_TRIM2 (at 0x11bf2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S3_PS_PS_TRIM3"
      sgroup "S3_PS_PS_TRIM3 (at 0x11bf3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AUTO_THRS_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      sgroup "S4_CTRL_REVISION1 (at 0x11d00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      sgroup "S4_CTRL_REVISION2 (at 0x11d01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      sgroup "S4_CTRL_REVISION3 (at 0x11d02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      sgroup "S4_CTRL_REVISION4 (at 0x11d03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      sgroup "S4_CTRL_PERPH_TYPE (at 0x11d04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      sgroup "S4_CTRL_PERPH_SUBTYPE (at 0x11d05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS1"
      sgroup "S4_CTRL_STATUS1 (at 0x11d08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (VREG_ERR_FALSE),1 (VREG_ERR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_FAULT),1 (FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_TRUE                                  = " "0 (PS_TRUE_FALSE),1 (PS_TRUE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIME_SPEND_PWM_READY                     = " "0 (TIME_SPEND_PWM_READY_FALSE),1 (TIME_SPEND_PWM_READY_TRUE)"
    tree.end
    tree "S4_CTRL_STATUS2"
      sgroup "S4_CTRL_STATUS2 (at 0x11d09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIME_SPEND_PWM                           = "
    tree.end
    tree "S4_CTRL_STATUS3"
      sgroup "S4_CTRL_STATUS3 (at 0x11d0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   CAL_FAULT                                = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      sgroup "S4_CTRL_INT_RT_STS (at 0x11d10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (VREG_FAULT_FALSE),1 (VREG_FAULT_TRUE)"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      sgroup "S4_CTRL_INT_SET_TYPE (at 0x11d11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      sgroup "S4_CTRL_INT_POLARITY_HIGH (at 0x11d12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      sgroup "S4_CTRL_INT_POLARITY_LOW (at 0x11d13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      sgroup "S4_CTRL_INT_LATCHED_CLR (at 0x11d14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      sgroup "S4_CTRL_INT_EN_SET (at 0x11d15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      sgroup "S4_CTRL_INT_EN_CLR (at 0x11d16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      sgroup "S4_CTRL_INT_LATCHED_STS (at 0x11d18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      sgroup "S4_CTRL_INT_PENDING_STS (at 0x11d19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      sgroup "S4_CTRL_INT_MID_SEL (at 0x11d1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      sgroup "S4_CTRL_INT_PRIORITY (at 0x11d1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S4_CTRL_VSET_LB"
      sgroup "S4_CTRL_VSET_LB (at 0x11d40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "S4_CTRL_VSET_UB"
      sgroup "S4_CTRL_VSET_UB (at 0x11d41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "S4_CTRL_VSET_VALID_LB"
      sgroup "S4_CTRL_VSET_VALID_LB (at 0x11d42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID_LB                            = "
    tree.end
    tree "S4_CTRL_VSET_VALID_UB"
      sgroup "S4_CTRL_VSET_VALID_UB (at 0x11d43)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "S4_CTRL_PFM_CTL"
      sgroup "S4_CTRL_PFM_CTL (at 0x11d44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S4_CTRL_MODE_CTL1"
      sgroup "S4_CTRL_MODE_CTL1 (at 0x11d45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S4_CTRL_EN_CTL"
      sgroup "S4_CTRL_EN_CTL (at 0x11d46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S4_CTRL_FOLLOW_HWEN"
      sgroup "S4_CTRL_FOLLOW_HWEN (at 0x11d47)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_AWAKE_CFG                         = " "0 (FOLLOW_AWAKE_CFG_FALSE),1 (FOLLOW_AWAKE_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HWEN2_CFG                         = " "0 (FOLLOW_HWEN2_CFG_FALSE),1 (FOLLOW_HWEN2_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_HWEN1_CFG                         = " "0 (FOLLOW_HWEN1_CFG_FALSE),1 (FOLLOW_HWEN1_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_HWEN0_CFG                         = " "0 (FOLLOW_HWEN0_CFG_FALSE),1 (FOLLOW_HWEN0_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HWEN2                          = " "0 (EN_FOLLOW_HWEN2_FALSE),1 (EN_FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HWEN1                          = " "0 (EN_FOLLOW_HWEN1_FALSE),1 (EN_FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HWEN0                          = " "0 (EN_FOLLOW_HWEN0_FALSE),1 (EN_FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S4_CTRL_PD_CTL"
      sgroup "S4_CTRL_PD_CTL (at 0x11d48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ENABLE_FALSE),1 (STRONG_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_ENABLE_FALSE),1 (WEAK_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_PFM_FALSE),1 (WEAK_PD_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_PWM_FALSE),1 (WEAK_PD_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAK_PD_EN_FALSE),1 (LEAK_PD_EN_TRUE)"
    tree.end
    tree "S4_CTRL_MODE_CTL2"
      sgroup "S4_CTRL_MODE_CTL2 (at 0x11d49)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S4_CTRL_RETENTION_CTL1"
      sgroup "S4_CTRL_RETENTION_CTL1 (at 0x11d4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_P1                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_M1                            = "
    tree.end
    tree "S4_CTRL_RETENTION_CTL2"
      sgroup "S4_CTRL_RETENTION_CTL2 (at 0x11d4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_X2                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_DIV2                          = "
    tree.end
    tree "S4_CTRL_RETENTION_STS1"
      sgroup "S4_CTRL_RETENTION_STS1 (at 0x11d4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_PERIOD                               = "
    tree.end
    tree "S4_CTRL_RETENTION_STS2"
      sgroup "S4_CTRL_RETENTION_STS2 (at 0x11d4d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d4d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d4d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_COUNT                                = "
    tree.end
    tree "S4_CTRL_RETENTION_STS3"
      sgroup "S4_CTRL_RETENTION_STS3 (at 0x11d4e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d4e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d4e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES                               = "
    tree.end
    tree "S4_CTRL_FREQ_CTL"
      sgroup "S4_CTRL_FREQ_CTL (at 0x11d50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S4_CTRL_COMP_CAP_C1_C2_CTL"
      sgroup "S4_CTRL_COMP_CAP_C1_C2_CTL (at 0x11d51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   C1_CTRL                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   C2_CTRL                                  = " "0 (C2_CAP_0P0_PF),1 (C2_CAP_0P2_PF),2 (C2_CAP_0P4_PF),3 (C2_CAP_0P6_PF)"
    tree.end
    tree "S4_CTRL_COMP_CAP_C3_CTL"
      sgroup "S4_CTRL_COMP_CAP_C3_CTL (at 0x11d52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   C3_CTRL                                  = "
    tree.end
    tree "S4_CTRL_R1_R2_CTL"
      sgroup "S4_CTRL_R1_R2_CTL (at 0x11d53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   R1_CTL                                   = "
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   R2_CTL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_BUCK_SNS_CTL"
      sgroup "S4_CTRL_BUCK_SNS_CTL (at 0x11d54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SNS_SEL                                  = " "0 (SNS_SEL_0_VREG_SX),1 (SNS_SEL_1_VIN_LDO)"
    tree.end
    tree "S4_CTRL_RAMP_AMPLITUDE_CTL"
      sgroup "S4_CTRL_RAMP_AMPLITUDE_CTL (at 0x11d56)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_FREQ_CTL_LOGIC                    = " "0 (FOLLOW_FREQ_CTL_LOGIC_0_RAMP_AMPLITUDE),1 (FOLLOW_FREQ_CTL_LOGIC_1_FREQ_CTL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMPAMPLITUDE                        = "
    tree.end
    tree "S4_CTRL_DMAX_CTL"
      sgroup "S4_CTRL_DMAX_CTL (at 0x11d58)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S4_CTRL_PULSE_SKIP_CTL"
      sgroup "S4_CTRL_PULSE_SKIP_CTL (at 0x11d59)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_4CYCLE),1 (PS_TIME_HYST_8CYCLE),2 (PS_TIME_HYST_16CYCLE),3 (PS_TIME_HYST_32CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S4_CTRL_PS_THRES_ERRAMP"
      sgroup "S4_CTRL_PS_THRES_ERRAMP (at 0x11d5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ERRAMP                           = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_VRST_RANGE                            = " "0 (PS_VRST_RANGE_LOW),1 (PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VRST                                  = " "0 (PS_VRST_0MV),1 (PS_VRST_VOUTDIV30),2 (PS_VRST_VOUTDIV20),3 (PS_VRST_VOUTDIV15),4 (PS_VRST_VOUTDIV12),5 (PS_VRST_VOUTDIV10),6 (PS_VRST_VOUTDIV9),7 (PS_VRST_VOUTDIV8)"
    tree.end
    tree "S4_CTRL_AUTO_MODE_CTL"
      sgroup "S4_CTRL_AUTO_MODE_CTL (at 0x11d5b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_32CYCLES)"
    tree.end
    tree "S4_CTRL_INZERO_COUNT_CTL"
      sgroup "S4_CTRL_INZERO_COUNT_CTL (at 0x11d5c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PFM_COUNT_CTL"
      sgroup "S4_CTRL_PFM_COUNT_CTL (at 0x11d5d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S4_CTRL_PS_THRES_ILOAD"
      sgroup "S4_CTRL_PS_THRES_ILOAD (at 0x11d5e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ILOAD                            = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_METHOD_STEPPER                        = " "0 (PS_METHOD_STEPPER_ILOAD),1 (PS_METHOD_STEPPER_WINDOW)"
    tree.end
    tree "S4_CTRL_STEPPER_SS_CTL"
      sgroup "S4_CTRL_STEPPER_SS_CTL (at 0x11d60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_STEPPER_DELAY                         = " "0 (STEPPER_SS_2_CLK_CYCLES),1 (STEPPER_SS_4_CLK_CYCLES),2 (STEPPER_SS_8_CLK_CYCLES),3 (STEPPER_SS_16_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_STEPPER_VS_CTL"
      sgroup "S4_CTRL_STEPPER_VS_CTL (at 0x11d61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VS_STEPPER_DELAY                         = " "0 (STEPPER_VS_2_CLK_CYCLES),1 (STEPPER_VS_4_CLK_CYCLES),2 (STEPPER_VS_8_CLK_CYCLES),3 (STEPPER_VS_16_CLK_CYCLES)"
    tree.end
    tree "S4_CTRL_QM_PS_EXIT"
      sgroup "S4_CTRL_QM_PS_EXIT (at 0x11d63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QM_MODE                                  = " "0 (QM_MODE_FORCE_PFM_DITHER_ENABLED),1 (QM_MODE_FORCED_PWM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QM_FOLLOW                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QM_PS_METHOD                             = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QM_PS_VRST_RANGE                         = " "0 (QM_PS_VRST_RANGE_LOW),1 (QM_PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   QM_PS_VRST                               = " "0 (QM_PS_VRST_0MV),1 (QM_PS_VRST_VOUTDIV30),2 (QM_PS_VRST_VOUTDIV20),3 (QM_PS_VRST_VOUTDIV15),4 (QM_PS_VRST_VOUTDIV12),5 (QM_PS_VRST_VOUTDIV10),6 (QM_PS_VRST_VOUTDIV9),7 (QM_PS_VRST_VOUTDIV8)"
    tree.end
    tree "S4_CTRL_OCP"
      sgroup "S4_CTRL_OCP (at 0x11d66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_LATCH_EN                             = " "0 (OCP_LATCH_EN_FALSE),1 (OCP_LATCH_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_FOLDBACK_EN                         = " "0 (FORCE_FOLDBACK_FALSE),1 (FORCE_FOLDBACK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   INZERO_WAIT_OCP_TIMER                    = " "0 (INZERO_WAIT_40US_OCP_TIMER_320US),1 (INZERO_WAIT_80US_OCP_TIMER_640US),2 (INZERO_WAIT_160US_OCP_TIMER_1280_US),3 (INZERO_WAIT_160US_OCP_TIMER_1280US)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_EN_FALSE),1 (OCP_GLOBAL_BROADCAST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLEAR                         = " "0 (OCP_STATUS_CLEAR_FALSE),1 (OCP_STATUS_CLEAR_TRUE)"
    tree.end
    tree "S4_CTRL_ULS_VSET_LB"
      sgroup "S4_CTRL_ULS_VSET_LB (at 0x11d68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "S4_CTRL_ULS_VSET_UB"
      sgroup "S4_CTRL_ULS_VSET_UB (at 0x11d69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "S4_CTRL_STATUS_DEB_CTL"
      sgroup "S4_CTRL_STATUS_DEB_CTL (at 0x11d70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_0_LFRC_DIV2),1 (READY_DEB_1_LFRC_DIV4),2 (READY_DEB_2_LFRC_DIV8),3 (READY_DEB_3_LFRC_DIV16)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_0_LFRC_DIV2),1 (ERROR_DEB_1_LFRC_DIV4),2 (ERROR_DEB_2_LFRC_DIV8),3 (ERROR_DEB_3_LFRC_DIV16)"
    tree.end
    tree "S4_CTRL_CAL_TIMER_CTL"
      sgroup "S4_CTRL_CAL_TIMER_CTL (at 0x11d71)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER                                = "
    tree.end
    tree "S4_CTRL_CAL_START"
      sgroup "S4_CTRL_CAL_START (at 0x11d72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQ_WR_PULSE                         = " "0 (CAL_REQ_WR_PULSE_FALSE),1 (CAL_REQ_WR_PULSE_TRUE)"
    tree.end
    tree "S4_CTRL_CAL_TRIM1"
      sgroup "S4_CTRL_CAL_TRIM1 (at 0x11d73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERR_AMP_TRIM_AUTO                        = "
    tree.end
    tree "S4_CTRL_CAL_TRIM2"
      sgroup "S4_CTRL_CAL_TRIM2 (at 0x11d74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM_AUTO                      = "
    tree.end
    tree "S4_CTRL_CAL_TRIM3"
      sgroup "S4_CTRL_CAL_TRIM3 (at 0x11d75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM_AUTO                       = "
    tree.end
    tree "S4_CTRL_CAL_TRIM4"
      sgroup "S4_CTRL_CAL_TRIM4 (at 0x11d76)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM_AUTO                      = "
    tree.end
    tree "S4_CTRL_CAL_TRIM5"
      sgroup "S4_CTRL_CAL_TRIM5 (at 0x11d77)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM_AUTO                  = "
    tree.end
    tree "S4_CTRL_CAL_TRIM_EN_CTL"
      sgroup "S4_CTRL_CAL_TRIM_EN_CTL (at 0x11d78)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ERR_AMP_TRIM_CAL_EN                      = " "0 (reserved),1 (ERR_AMP_TRIM_CAL_EN_MAN),2 (reserved),3 (ERR_AMP_TRIM_CAL_EN_AUTO)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PWM_THRES_TRIM_CAL_EN                    = " "0 (PWM_THRES_TRIM_CAL_EN_MAN),1 (PWM_THRES_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_TRIM_CAL_EN                     = " "0 (PFM_COMP_TRIM_CAL_EN_MAN),1 (PFM_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VDIP_COMP_TRIM_CAL_EN                    = " "0 (VDIP_COMP_TRIM_CAL_EN_MAN),1 (VDIP_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_RAMP_PEAK_TRIM_CAL_EN                = " "0 (PWM_RAMP_PEAK_TRIM_CAL_EN_MAN),1 (PWM_RAMP_PEAK_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_CAL_ENG_EN                          = " "0 (TRIM_CAL_ENG_EN_FALSE),1 (TRIM_CAL_ENG_EN_TRUE)"
    tree.end
    tree "S4_CTRL_CTLR_MISC"
      sgroup "S4_CTRL_CTLR_MISC (at 0x11d7e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d7e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIS_PFM_DIR_SAMPLE                       = " "0 (DIS_PFM_DIR_SAMPLE_FALSE),1 (DIS_PFM_DIR_SAMPLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIS_VDIP_HCPFM_GATE                      = " "0 (DIS_VDIP_HCPFM_GATE_FALSE),1 (DIS_VDIP_HCPFM_GATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_PRECH_EXTEND                         = " "0 (DIS_PRECH_EXTEND_FALSE),1 (DIS_PRECH_EXTEND_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_FORCE_PWM                            = " "0 (DIS_FORCE_PWM_FALSE),1 (DIS_FORCE_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_CLAMP                                = " "0 (DIS_CLAMP_FALSE),1 (DIS_CLAMP_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PS_TIMEOUT                           = " "0 (DIS_PS_TIMEOUT_FALSE),1 (DIS_PS_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_ERRAMP_TRIM_BUF                      = " "0 (DIS_ERRAMP_TRIM_BUF_FALSE),1 (DIS_ERRAMP_TRIM_BUF_TRUE)"
    tree.end
    tree "S4_CTRL_SCRATCH_REG"
      sgroup "S4_CTRL_SCRATCH_REG (at 0x11d7f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d7f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d7f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SCRATCH_7                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCRATCH_6                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCRATCH_5                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCRATCH_4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SCRATCH_3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SCRATCH_2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SCRATCH_1                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SCRATCH_0                                = " "0, 1"
    tree.end
    tree "S4_CTRL_GANG_CTL1"
      sgroup "S4_CTRL_GANG_CTL1 (at 0x11dc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_CTRL_GANG_CTL2"
      sgroup "S4_CTRL_GANG_CTL2 (at 0x11dc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S4_CTRL_SEC_ACCESS"
      sgroup "S4_CTRL_SEC_ACCESS (at 0x11dd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      sgroup "S4_CTRL_PERPH_RESET_CTL1 (at 0x11dd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      sgroup "S4_CTRL_PERPH_RESET_CTL2 (at 0x11dd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      sgroup "S4_CTRL_PERPH_RESET_CTL3 (at 0x11dda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      sgroup "S4_CTRL_PERPH_RESET_CTL4 (at 0x11ddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      sgroup "S4_CTRL_INT_TEST1 (at 0x11de0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      sgroup "S4_CTRL_INT_TEST_VAL (at 0x11de1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT_TEST_VAL                  = " "0 (VREG_READY_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_READY_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_FAULT_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S4_CTRL_CTLR_TEST1"
      sgroup "S4_CTRL_CTLR_TEST1 (at 0x11de2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_SEL_NORMAL_OPERATION),1 (ATEST1_SEL_ERR_AMP_OUT),2 (ATEST1_SEL_VREF_DAC),3 (ATEST1_SEL_VRAMP_PK),4 (ATEST1_SEL_VREF_RESET),5 (ATEST1_SEL_VRAMP),6 (ATEST1_SEL_VFB_DIV_PFM),7 (ATEST1_SEL_ERR_AMP_IN_MNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_SEL_NORMAL_OPERATION),1 (DTEST1_SEL_BUCK_CLK),2 (DTEST1_SEL_PS_COMP),3 (DTEST1_SEL_PULSE_SKIP_FSM),4 (DTEST1_SEL_PWM_COMP),5 (DTEST1_SEL_LO_COMP_FSM),6 (DTEST1_SEL_PFM_COMP_FSM),7 (DTEST1_SEL_MODE_FSM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_CTRL_CTLR_TEST2"
      sgroup "S4_CTRL_CTLR_TEST2 (at 0x11de3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_SEL_NORMAL_OPERATION),1 (ATEST2_SEL_VREF_DAC_EA),2 (ATEST2_SEL_A_REG_GNDC),3 (ATEST2_SEL_VRAMP_BOT),4 (ATEST2_SEL_ERRAMP_OUT),5 (ATEST2_SEL_AVDD),6 (ATEST2_SEL_VFB_DIV_PSKIP),7 (ATEST2_SEL_VOUT_SNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_SEL_NORMAL_OPERATION),1 (DTEST2_SEL_CLK_LFRC),2 (DTEST2_SEL_INZ_CNT_DONE),3 (DTEST2_SEL_PDRV_EXTEND),4 (DTEST2_SEL_PS_EXIT),5 (DTEST2_SEL_PS_ENTER_WIN),6 (DTEST2_SEL_IPLIM_INT_MODE),7 (DTEST2_SEL_FORCE_PS_FOLDBACK)"
    tree.end
    tree "S4_CTRL_CTLR_TEST3"
      sgroup "S4_CTRL_CTLR_TEST3 (at 0x11de4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST3_SEL                               = " "0 (DTEST3_SEL_NORMAL_OPERATION),1 (DTEST3_SEL_ERRAMP_DIG),2 (DTEST3_SEL_VRAMP_COMP_DIG),3 (DTEST3_SEL_PFM_COMP_CNTR),4 (DTEST3_SEL_VDIP_COMP),5 (DTEST3_SEL_TRIM_MUX_OUT),6 (DTEST3_SEL_CLAMP_ON),7 (DTEST3_SEL_RAMP_RST)"
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      sgroup "S4_CTRL_TRIM_NUM (at 0x11df0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_CTRL_CAL_MANUAL"
      sgroup "S4_CTRL_CAL_MANUAL (at 0x11df1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MAN_CAL                                  = "
    tree.end
    tree "S4_CTRL_CTL_TRIM1"
      sgroup "S4_CTRL_CTL_TRIM1 (at 0x11df2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM                           = "
    tree.end
    tree "S4_CTRL_CTL_TRIM2"
      sgroup "S4_CTRL_CTL_TRIM2 (at 0x11df3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM                            = "
    tree.end
    tree "S4_CTRL_CTL_TRIM4"
      sgroup "S4_CTRL_CTL_TRIM4 (at 0x11df4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S4_CTRL_CTL_TRIM3"
      sgroup "S4_CTRL_CTL_TRIM3 (at 0x11df5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      sgroup "S4_FREQ_REVISION1 (at 0x11f00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      sgroup "S4_FREQ_REVISION2 (at 0x11f01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      sgroup "S4_FREQ_PERPH_TYPE (at 0x11f04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      sgroup "S4_FREQ_PERPH_SUBTYPE (at 0x11f05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      sgroup "S4_FREQ_CLK_ENABLE (at 0x11f46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      sgroup "S4_FREQ_CLK_DIV (at 0x11f50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      sgroup "S4_FREQ_CLK_PHASE (at 0x11f51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      sgroup "S4_FREQ_GANG_CTL1 (at 0x11fc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      sgroup "S4_FREQ_GANG_CTL2 (at 0x11fc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      sgroup "S4_FREQ_SEC_ACCESS (at 0x11fd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      sgroup "S4_FREQ_PERPH_RESET_CTL2 (at 0x11fd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      sgroup "S4_FREQ_PERPH_RESET_CTL3 (at 0x11fda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      sgroup "S4_FREQ_PERPH_RESET_CTL4 (at 0x11fdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S4_FREQ_TEST1"
      sgroup "S4_FREQ_TEST1 (at 0x11fe2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fe20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      sgroup "S4_PS_REVISION1 (at 0x11e00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      sgroup "S4_PS_REVISION2 (at 0x11e01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      sgroup "S4_PS_REVISION3 (at 0x11e02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      sgroup "S4_PS_REVISION4 (at 0x11e03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      sgroup "S4_PS_PERPH_TYPE (at 0x11e04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      sgroup "S4_PS_PERPH_SUBTYPE (at 0x11e05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_STATUS3"
      sgroup "S4_PS_STATUS3 (at 0x11e0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
    tree.end
    tree "S4_PS_STATUS4"
      sgroup "S4_PS_STATUS4 (at 0x11e0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (ECM_MISSED_DATA_FALSE),1 (ECM_MISSED_DATA_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ECM_DATA_TYPE                            = " "0 (ECM_DATA_TYPE_MEASUREMENT),1 (ECM_DATA_TYPE_REFERENCE),2 (ECM_DATA_TYPE_OFFSET),3 (ECM_DATA_TYPE_RESERVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_PRESENT_FALSE),1 (ECM_PRESENT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ECM_REQ_SW_CALIB                         = " "0 (ECM_REQ_SW_CALIB_FALSE),1 (ECM_REQ_SW_CALIB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ECM_DATA_NEGATIVE                        = " "0 (ECM_DATA_NEGATIVE_FALSE),1 (ECM_DATA_NEGATIVE_TRUE)"
    tree.end
    tree "S4_PS_PFM_FREQ_CTL"
      sgroup "S4_PS_PFM_FREQ_CTL (at 0x11e44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_FREQ_DITH_EN                         = " "0 (PFM_DITHERING_EN_FALSE),1 (PFM_DITHERING_EN_TRUE)"
    tree.end
    tree "S4_PS_PFM_FREQ_CFG"
      sgroup "S4_PS_PFM_FREQ_CFG (at 0x11e45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FREQ_DITH_NUMBIT_SEL                     = " "0 (NUMBIT_SEL_2B),1 (NUMBIT_SEL_3B)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DITH_TIMING_CTL                          = " "0 (DITH_CTL_PFM_COMP_CLK),1 (DITH_CTL_PFM_COMP_DIV4_CLK),2 (DITH_CTL_PFM_COMP_DIV32_CLK),3 (DITH_CTL_PFM_COMP_DIV128_CLK),4 (DITH_CTL_LFRC_CLK),5 (DITH_CTL_LFRC_DIV4_CLK),6 (DITH_CTL_LFRC_DIV32_CLK),7 (DITH_CTL_LFRC_DIV128_CLK)"
    tree.end
    tree "S4_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S4_PS_PWM_CURRENT_LIM_CTL (at 0x11e4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CURRENT_LIM_AUTOINT_SEL                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PWM_SEL                      = "
    tree.end
    tree "S4_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S4_PS_PFM_CURRENT_LIM_CTL (at 0x11e4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_PWM_CURRENT_LIM_EN                   = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PFM_SEL                      = "
    tree.end
    tree "S4_PS_ILIM_SS_CTL"
      sgroup "S4_PS_ILIM_SS_CTL (at 0x11e4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ILIM_SS_SEL                              = "
    tree.end
    tree "S4_PS_ISNS_THRES"
      sgroup "S4_PS_ISNS_THRES (at 0x11e5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_ENTRY_AUTO                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PS_ENTRY_PWM                             = "
    tree.end
    tree "S4_PS_QM_PS_ENTRY"
      sgroup "S4_PS_QM_PS_ENTRY (at 0x11e63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_ENTRY                           = "
    tree.end
    tree "S4_PS_SWITCH_SIZE_CTL"
      sgroup "S4_PS_SWITCH_SIZE_CTL (at 0x11e70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_MIN),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_MIN),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S4_PS_DEAD_TIME_CTRL"
      sgroup "S4_PS_DEAD_TIME_CTRL (at 0x11e72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S4_PS_BLNK_TIME_CTL"
      sgroup "S4_PS_BLNK_TIME_CTL (at 0x11e73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S4_PS_INZERO_CTL"
      sgroup "S4_PS_INZERO_CTL (at 0x11e74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S4_PS_DIG_FSM_CTL"
      sgroup "S4_PS_DIG_FSM_CTL (at 0x11e75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_LAT_DIS                              = " "0 (FSM_DISABLE_LATCH_FALSE),1 (FSM_DISABLE_LATCH_TRUE)"
    tree.end
    tree "S4_PS_CAL_EN_CTL1"
      sgroup "S4_PS_CAL_EN_CTL1 (at 0x11e78)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIM_TRIM_CAL_EN                        = " "0 (IPLIM_TRIM_CAL_EN_FALSE),1 (IPLIM_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_THRES_TRIM_CAL_EN                   = " "0 (AUTO_THRES_TRIM_CAL_EN_FALSE),1 (AUTO_THRES_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INZERO_TRIM_CAL_EN                       = " "0 (INZERO_TRIM_CAL_EN_FALSE),1 (INZERO_TRIM_CAL_EN_TRUE)"
    tree.end
    tree "S4_PS_PWR_STG_MISC"
      sgroup "S4_PS_PWR_STG_MISC (at 0x11e7e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0 (DUTY_EST_CLK_SEL_BIT1_FALSE),1 (DUTY_EST_CLK_SEL_BIT1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0 (DUTY_EST_CLK_SEL_BIT0_FALSE),1 (DUTY_EST_CLK_SEL_BIT0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0 (AUTO_BLOCK_THRESH_NORMAL),1 (AUTO_BLOCK_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0 (PFM_CURRENT_LIMIT_THRESH_NORMAL),1 (PFM_CURRENT_LIMIT_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (AUTO_MODE_BW_SEL_NORMAL),1 (AUTO_MODE_BW_SEL_QUARTER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0 (BYPASS_CMN_MODE_ECM_FALSE),1 (BYPASS_CMN_MODE_ECM_TRUE)"
    tree.end
    tree "S4_PS_ECM_EN_CTL"
      sgroup "S4_PS_ECM_EN_CTL (at 0x11e80)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_EN_FALSE),1 (ECM_LOCAL_EN_TRUE)"
    tree.end
    tree "S4_PS_ECM_CFG_0"
      sgroup "S4_PS_ECM_CFG_0 (at 0x11e81)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SENSE_SW_NTWK_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   FET_REF_SIZE_SEL                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_ADC_REF_CHOPPING                      = " "0 (EN_ADC_REF_CHOPPING_FALSE),1 (EN_ADC_REF_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_ADC_IN_CHOPPING                       = " "0 (EN_ADC_IN_CHOPPING_FALSE),1 (EN_ADC_IN_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SENSE_FILT_BW_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ADC_GAIN_SEL                             = " "0 (ADC_GAIN_SEL_GAIN_OF_2),1 (ADC_GAIN_SEL_GAIN_OF_3),2 (ADC_GAIN_SEL_GAIN_OF_3P0),3 (ADC_GAIN_SEL_GAIN_OF_4)"
    tree.end
    tree "S4_PS_ECM_CFG_1"
      sgroup "S4_PS_ECM_CFG_1 (at 0x11e82)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   ECM_BIAS_CTRL                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ECM_REF_OFF_CTRL                         = " "0 (ECM_REF_OFF_CTRL_0),1 (ECM_REF_OFF_CTRL_1),2 (ECM_REF_OFF_CTRL_2),3 (ECM_REF_OFF_CTRL_3),4 (ECM_REF_OFF_CTRL_4),5 (ECM_REF_OFF_CTRL_5),6 (ECM_REF_OFF_CTRL_6),7 (ECM_REF_OFF_CTRL_7)"
    tree.end
    tree "S4_PS_ECM_DATA_LB"
      sgroup "S4_PS_ECM_DATA_LB (at 0x11e84)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "S4_PS_ECM_DATA_UB"
      sgroup "S4_PS_ECM_DATA_UB (at 0x11e85)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "S4_PS_SEC_ACCESS"
      sgroup "S4_PS_SEC_ACCESS (at 0x11ed0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      sgroup "S4_PS_PERPH_RESET_CTL2 (at 0x11ed9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      sgroup "S4_PS_PERPH_RESET_CTL3 (at 0x11eda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      sgroup "S4_PS_PERPH_RESET_CTL4 (at 0x11edb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S4_PS_FORCE_FET_TEST"
      sgroup "S4_PS_FORCE_FET_TEST (at 0x11ee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S4_PS_PWR_STG_TEST1"
      sgroup "S4_PS_PWR_STG_TEST1 (at 0x11ee4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_NORMAL),1 (ATEST1_FET_KSP1),2 (ATEST1_REF_KSP1),3 (ATEST1_ECM_OUT_CM),4 (ATEST1_A_ECM_ATEST_FORCE1),5 (ATEST1_VREF_FILT),6 (ATEST1_VREF_SNS),7 (ATEST1_FLOATING)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_MISSION_MODE),1 (DTEST1_D_AUTO_PS_THRES_COMP),2 (DTEST1_D_DC_VOUT_CLK_1),3 (DTEST1_D_PSW_DRV_SEL),4 (DTEST1_D_INZ_COMP_LOC),5 (DTEST1_D_IPLIM_COMP_LOC),6 (DTEST1_ECM_PHI1),7 (DTEST1_D_NSW_DRV_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S4_PS_PWR_STG_TEST2"
      sgroup "S4_PS_PWR_STG_TEST2 (at 0x11ee5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_MISSION_MODE),1 (ATEST2_FET_KSP2),2 (ATEST2_REF_KSP2),3 (ATEST2_ECM_VBIAS),4 (ATEST2_A_ECM_ATEST_FORCE2),5 (ATEST2_VSW_FILT),6 (ATEST2_VSW_SNS),7 (ATEST2_SPARE)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_MISSION_MODE),1 (DTEST2_D_END_MIN_PON),2 (DTEST2_D_DC_COMP_OUT),3 (DTEST2_D_PFM_ENTRY_BUF),4 (DTEST2_D_INZ_COMP_EXTEND),5 (DTEST2_D_PGATE_BLNK),6 (DTEST2_ECM_PHI2),7 (DTEST2_D_PSK_ENTRY_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIM_TEST_CTRL                          = " "0 (IPLIM_TEST_MODE_CTRL_RESERVED_0),1 (IPLIM_TEST_MODE_CTRL_RESERVED_1),2 (IPLIM_TEST_MODE_CTRL_RESERVED_2),3 (IPLIM_TEST_MODE_CTRL_RESERVED_3)"
    tree.end
    tree "S4_PS_PWR_STG_TEST3"
      sgroup "S4_PS_PWR_STG_TEST3 (at 0x11ee6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST3_SEL                               = " "0 (DTEST3_MISSION_MODE),1 (DTEST3_D_D2A_ECM_DTEST_DEC_0_D_D2A_ECM_ADC_INPUT_POLARITY),2 (DTEST3_D_D2A_ECM_DTEST_DEC_2_D_D2A_ECM_ADC_INPUT_MUX_CTRL_1),3 (DTEST3_D_D2A_ECM_DTEST_DEC_4_D_CHOP_SYNC),4 (DTEST3_D_D2A_ECM_DTEST_DEC_6_D_CAL_STROBE),5 (DTEST3_CAL_MUX_FILT_OUT),6 (DTEST3_ECM_COMP_P),7 (DTEST3_ECM_COMP_N)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST4_SEL                               = " "0 (DTEST4_MISSION_MODE),1 (DTEST4_D_D2A_ECM_DTEST_DEC_1_D_D2A_ECM_ADC_INPUT_MUX_CTRL_0),2 (DTEST4_D_D2A_ECM_DTEST_DEC_3_D_D2A_ECM_ADC_INPUT_MUX_CTRL_2),3 (DTEST4_D_D2A_ECM_DTEST_DEC_5_D_GLOBAL_EN),4 (DTEST4_D_D2A_ECM_DTEST_DEC_7_D_STROBE),5 (DTEST4_SPARE),6 (DTEST4_ECM_ADC_INPUT_POLARITY),7 (DTEST4_D_ADC_CLR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SENSE                                 = " "0 (EN_SENSE_FALSE),1 (EN_SENSE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_ADC                                   = " "0 (EN_ADC_FALSE),1 (EN_ADC_TRUE)"
    tree.end
    tree "S4_PS_PWR_STG_TEST4"
      sgroup "S4_PS_PWR_STG_TEST4 (at 0x11ee7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_TEST_EN                              = " "0 (ECM_TEST_EN_FALSE),1 (ECM_TEST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ECM_INPUT_MUX_CTRL                       = " "0 (ECM_INPUT_MUX_CTRL_0),1 (ECM_INPUT_MUX_CTRL_1),2 (ECM_INPUT_MUX_CTRL_2),3 (ECM_INPUT_MUX_CTRL_3),4 (ECM_INPUT_MUX_CTRL_4),5 (ECM_INPUT_MUX_CTRL_5),6 (ECM_INPUT_MUX_CTRL_6),7 (ECM_INPUT_MUX_CTRL_7)"
    tree.end
    tree "S4_PS_TRIM_NUM"
      sgroup "S4_PS_TRIM_NUM (at 0x11ef0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S4_PS_PS_TRIM1"
      sgroup "S4_PS_PS_TRIM1 (at 0x11ef1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IPLIM_TRIM                               = "
    tree.end
    tree "S4_PS_PS_TRIM2"
      sgroup "S4_PS_PS_TRIM2 (at 0x11ef2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S4_PS_PS_TRIM3"
      sgroup "S4_PS_PS_TRIM3 (at 0x11ef3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AUTO_THRS_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "S5_CTRL"
  tree "S5_CTRL"
    tree "S5_CTRL_REVISION1"
      sgroup "S5_CTRL_REVISION1 (at 0x12000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION2"
      sgroup "S5_CTRL_REVISION2 (at 0x12001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_CTRL_REVISION3"
      sgroup "S5_CTRL_REVISION3 (at 0x12002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION4"
      sgroup "S5_CTRL_REVISION4 (at 0x12003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_CTRL_PERPH_TYPE"
      sgroup "S5_CTRL_PERPH_TYPE (at 0x12004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_CTRL_PERPH_SUBTYPE"
      sgroup "S5_CTRL_PERPH_SUBTYPE (at 0x12005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_CTRL_STATUS1"
      sgroup "S5_CTRL_STATUS1 (at 0x12008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_READY                               = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_ERROR                               = " "0 (VREG_ERR_FALSE),1 (VREG_ERR_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_OCP                                 = " "0 (NO_FAULT),1 (FAULT)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_TRUE                                 = " "0 (NPM_VREGOK_FALSE),1 (NPM_VREGOK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_TRUE                                  = " "0 (PS_TRUE_FALSE),1 (PS_TRUE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEPPER_DONE                             = " "0 (STEPPER_DONE_FALSE),1 (STEPPER_DONE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TIME_SPEND_PWM_READY                     = " "0 (TIME_SPEND_PWM_READY_FALSE),1 (TIME_SPEND_PWM_READY_TRUE)"
    tree.end
    tree "S5_CTRL_STATUS2"
      sgroup "S5_CTRL_STATUS2 (at 0x12009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TIME_SPEND_PWM                           = "
    tree.end
    tree "S5_CTRL_STATUS3"
      sgroup "S5_CTRL_STATUS3 (at 0x1200a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80200a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x200a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_REQUEST                              = " "0 (CAL_REQUEST_FALSE),1 (CAL_REQUEST_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x1--0x5 1 "  [ 5: 1]   CAL_FAULT                                = "
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0 (CTL_CAL_DONE_FLAG_FALSE),1 (CTL_CAL_DONE_FLAG_TRUE)"
    tree.end
    tree "S5_CTRL_INT_RT_STS"
      sgroup "S5_CTRL_INT_RT_STS (at 0x12010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_RT_STS                        = " "0 (VREG_READY_FALSE),1 (VREG_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_RT_STS                        = " "0 (VREG_FAULT_FALSE),1 (VREG_FAULT_TRUE)"
    tree.end
    tree "S5_CTRL_INT_SET_TYPE"
      sgroup "S5_CTRL_INT_SET_TYPE (at 0x12011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_TYPE                          = " "0 (EDGE_TRIGGERED),1 (LEVEL_TRIGGERED)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_HIGH"
      sgroup "S5_CTRL_INT_POLARITY_HIGH (at 0x12012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "S5_CTRL_INT_POLARITY_LOW"
      sgroup "S5_CTRL_INT_POLARITY_LOW (at 0x12013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "S5_CTRL_INT_LATCHED_CLR"
      sgroup "S5_CTRL_INT_LATCHED_CLR (at 0x12014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_EN_SET"
      sgroup "S5_CTRL_INT_EN_SET (at 0x12015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "S5_CTRL_INT_EN_CLR"
      sgroup "S5_CTRL_INT_EN_CLR (at 0x12016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_EN_CLR                        = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_LATCHED_STS"
      sgroup "S5_CTRL_INT_LATCHED_STS (at 0x12018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INT_LATCHED)"
    tree.end
    tree "S5_CTRL_INT_PENDING_STS"
      sgroup "S5_CTRL_INT_PENDING_STS (at 0x12019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INT_PENDING)"
    tree.end
    tree "S5_CTRL_INT_MID_SEL"
      sgroup "S5_CTRL_INT_MID_SEL (at 0x1201a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80201a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x201a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (INT_MID_FALSE),1 (INT_MID_TRUE),2 (reserved),3 (reserved)"
    tree.end
    tree "S5_CTRL_INT_PRIORITY"
      sgroup "S5_CTRL_INT_PRIORITY (at 0x1201b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80201b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x201b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_FALSE),1 (INT_PRIORITY_TRUE)"
    tree.end
    tree "S5_CTRL_VSET_LB"
      sgroup "S5_CTRL_VSET_LB (at 0x12040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LB                                  = "
    tree.end
    tree "S5_CTRL_VSET_UB"
      sgroup "S5_CTRL_VSET_UB (at 0x12041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_UB                                  = "
    tree.end
    tree "S5_CTRL_VSET_VALID_LB"
      sgroup "S5_CTRL_VSET_VALID_LB (at 0x12042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID_LB                            = "
    tree.end
    tree "S5_CTRL_VSET_VALID_UB"
      sgroup "S5_CTRL_VSET_VALID_UB (at 0x12043)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VSET_VALID_UB                            = "
    tree.end
    tree "S5_CTRL_PFM_CTL"
      sgroup "S5_CTRL_PFM_CTL (at 0x12044)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0 (PFM_IBOOST_FALSE),1 (PFM_IBOOST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0 (PFM_HYST_3MV),1 (PFM_HYST_6MV)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0 (PFM_COMP_PLS_FLTR_100NS),1 (PFM_COMP_PLS_FLTR_250NS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0 (PFM_IPLIM_CTRL_FALSE),1 (PFM_IPLIM_CTRL_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0 (PFM_IPLIM_CTRL_75NS),1 (PFM_IPLIMI_CTRL_150NS),2 (PFM_IPLIM_CTRL_300NS),3 (PFM_IPLIM_CTRL_600NS)"
    tree.end
    tree "S5_CTRL_MODE_CTL1"
      sgroup "S5_CTRL_MODE_CTL1 (at 0x12045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_PRIMARY                             = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S5_CTRL_EN_CTL"
      sgroup "S5_CTRL_EN_CTL (at 0x12046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (BUCK_ENABLE_FALSE),1 (BUCK_ENABLE_TRUE)"
    tree.end
    tree "S5_CTRL_FOLLOW_HWEN"
      sgroup "S5_CTRL_FOLLOW_HWEN (at 0x12047)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FOLLOW_AWAKE_CFG                         = " "0 (FOLLOW_AWAKE_CFG_FALSE),1 (FOLLOW_AWAKE_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FOLLOW_HWEN2_CFG                         = " "0 (FOLLOW_HWEN2_CFG_FALSE),1 (FOLLOW_HWEN2_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_HWEN1_CFG                         = " "0 (FOLLOW_HWEN1_CFG_FALSE),1 (FOLLOW_HWEN1_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_HWEN0_CFG                         = " "0 (FOLLOW_HWEN0_CFG_FALSE),1 (FOLLOW_HWEN0_CFG_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_FOLLOW_PMIC_AWAKE                     = " "0 (EN_FOLLOW_PMIC_AWAKE_FALSE),1 (EN_FOLLOW_PMIC_AWAKE_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_FOLLOW_HWEN2                          = " "0 (EN_FOLLOW_HWEN2_FALSE),1 (EN_FOLLOW_HWEN2_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_FOLLOW_HWEN1                          = " "0 (EN_FOLLOW_HWEN1_FALSE),1 (EN_FOLLOW_HWEN1_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_FOLLOW_HWEN0                          = " "0 (EN_FOLLOW_HWEN0_FALSE),1 (EN_FOLLOW_HWEN0_TRUE)"
    tree.end
    tree "S5_CTRL_PD_CTL"
      sgroup "S5_CTRL_PD_CTL (at 0x12048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STRONG_PD_EN                             = " "0 (STRONG_PD_ENABLE_FALSE),1 (STRONG_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0 (WEAK_PD_ENABLE_FALSE),1 (WEAK_PD_ENABLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0 (WEAK_PD_PFM_FALSE),1 (WEAK_PD_PFM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0 (WEAK_PD_PWM_FALSE),1 (WEAK_PD_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LEAK_PD_EN                               = " "0 (LEAK_PD_EN_FALSE),1 (LEAK_PD_EN_TRUE)"
    tree.end
    tree "S5_CTRL_MODE_CTL2"
      sgroup "S5_CTRL_MODE_CTL2 (at 0x12049)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   MODE_SECONDARY                           = " "0 (FORCED_NPM_0),1 (FORCED_NPM_1),2 (FORCED_NPM_2),3 (FORCED_NPM_3),4 (FORCED_RETENTION),5 (FORCED_LPM),6 (AUTO_MODE),7 (FORCED_NPM_7)"
    tree.end
    tree "S5_CTRL_RETENTION_CTL1"
      sgroup "S5_CTRL_RETENTION_CTL1 (at 0x1204a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80204a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x204a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_P1                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_M1                            = "
    tree.end
    tree "S5_CTRL_RETENTION_CTL2"
      sgroup "S5_CTRL_RETENTION_CTL2 (at 0x1204b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80204b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x204b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SLP_CYCLES_X2                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES_DIV2                          = "
    tree.end
    tree "S5_CTRL_RETENTION_STS1"
      sgroup "S5_CTRL_RETENTION_STS1 (at 0x1204c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80204c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x204c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_PERIOD                               = "
    tree.end
    tree "S5_CTRL_RETENTION_STS2"
      sgroup "S5_CTRL_RETENTION_STS2 (at 0x1204d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80204d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x204d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SLP_COUNT                                = "
    tree.end
    tree "S5_CTRL_RETENTION_STS3"
      sgroup "S5_CTRL_RETENTION_STS3 (at 0x1204e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80204e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x204e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLP_CYCLES                               = "
    tree.end
    tree "S5_CTRL_FREQ_CTL"
      sgroup "S5_CTRL_FREQ_CTL (at 0x12050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S5_CTRL_COMP_CAP_C1_C2_CTL"
      sgroup "S5_CTRL_COMP_CAP_C1_C2_CTL (at 0x12051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   C1_CTRL                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   C2_CTRL                                  = " "0 (C2_CAP_0P0_PF),1 (C2_CAP_0P2_PF),2 (C2_CAP_0P4_PF),3 (C2_CAP_0P6_PF)"
    tree.end
    tree "S5_CTRL_COMP_CAP_C3_CTL"
      sgroup "S5_CTRL_COMP_CAP_C3_CTL (at 0x12052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   C3_CTRL                                  = "
    tree.end
    tree "S5_CTRL_R1_R2_CTL"
      sgroup "S5_CTRL_R1_R2_CTL (at 0x12053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   R1_CTL                                   = "
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   R2_CTL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_BUCK_SNS_CTL"
      sgroup "S5_CTRL_BUCK_SNS_CTL (at 0x12054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SNS_SEL                                  = " "0 (SNS_SEL_0_VREG_SX),1 (SNS_SEL_1_VIN_LDO)"
    tree.end
    tree "S5_CTRL_RAMP_AMPLITUDE_CTL"
      sgroup "S5_CTRL_RAMP_AMPLITUDE_CTL (at 0x12056)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_FREQ_CTL_LOGIC                    = " "0 (FOLLOW_FREQ_CTL_LOGIC_0_RAMP_AMPLITUDE),1 (FOLLOW_FREQ_CTL_LOGIC_1_FREQ_CTL)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMPAMPLITUDE                        = "
    tree.end
    tree "S5_CTRL_DMAX_CTL"
      sgroup "S5_CTRL_DMAX_CTL (at 0x12058)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0 (DMAX_EN_FALSE),1 (DMAX_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0 (DMAX_TIME_SEL_20NS),1 (DMAX_TIME_SEL_10NS)"
    tree.end
    tree "S5_CTRL_PULSE_SKIP_CTL"
      sgroup "S5_CTRL_PULSE_SKIP_CTL (at 0x12059)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0 (PS_EN_FALSE),1 (PS_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0 (PS_TIME_HYST_4CYCLE),1 (PS_TIME_HYST_8CYCLE),2 (PS_TIME_HYST_16CYCLE),3 (PS_TIME_HYST_32CYLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_METHOD                                = " "0 (PS_METHOD_ILOAD),1 (PS_METHOD_ERR_AMP)"
    tree.end
    tree "S5_CTRL_PS_THRES_ERRAMP"
      sgroup "S5_CTRL_PS_THRES_ERRAMP (at 0x1205a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80205a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x205a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ERRAMP                           = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_VRST_RANGE                            = " "0 (PS_VRST_RANGE_LOW),1 (PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VRST                                  = " "0 (PS_VRST_0MV),1 (PS_VRST_VOUTDIV30),2 (PS_VRST_VOUTDIV20),3 (PS_VRST_VOUTDIV15),4 (PS_VRST_VOUTDIV12),5 (PS_VRST_VOUTDIV10),6 (PS_VRST_VOUTDIV9),7 (PS_VRST_VOUTDIV8)"
    tree.end
    tree "S5_CTRL_AUTO_MODE_CTL"
      sgroup "S5_CTRL_AUTO_MODE_CTL (at 0x1205b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80205b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x205b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0 (PWM_PFM_SEL_PS_COMP),1 (PWM_PFM_SEL_INZERO)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0 (PFM_PWM_SEL_RESERVED),1 (PFM_PWM_SEL_VDIP_COMP),2 (PFM_PWM_SEL_IPLIM_CNTR),3 (PFM_PWM_SEL_VDIP_COMP_OR_IPLIM_CNTR)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0 (MODE_SEL_DLY_4CYCLES),1 (MODE_SEL_DLY_8CYCLES),2 (MODE_SEL_DLY_16CYCLES),3 (MODE_SEL_DLY_32CYCLES)"
    tree.end
    tree "S5_CTRL_INZERO_COUNT_CTL"
      sgroup "S5_CTRL_INZERO_COUNT_CTL (at 0x1205c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80205c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x205c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0 (WINDOW_WIDTH_1_COUNT),1 (WINDOW_WIDTH_2_COUNT),2 (WINDOW_WIDTH_4_COUNT),3 (WINDOW_WIDTH_8_COUNT),4 (WINDOW_WIDTH_16_COUNT),5 (WINDOW_WIDTH_32_COUNT),6 (WINDOW_WIDTH_64_COUNT),7 (WINDOW_WIDTH_128_COUNT)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PFM_COUNT_CTL"
      sgroup "S5_CTRL_PFM_COUNT_CTL (at 0x1205d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80205d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x205d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S5_CTRL_PS_THRES_ILOAD"
      sgroup "S5_CTRL_PS_THRES_ILOAD (at 0x1205e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80205e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x205e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PS_VRST_ILOAD                            = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PS_METHOD_STEPPER                        = " "0 (PS_METHOD_STEPPER_ILOAD),1 (PS_METHOD_STEPPER_WINDOW)"
    tree.end
    tree "S5_CTRL_STEPPER_SS_CTL"
      sgroup "S5_CTRL_STEPPER_SS_CTL (at 0x12060)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SS_STEPPER_DELAY                         = " "0 (STEPPER_SS_2_CLK_CYCLES),1 (STEPPER_SS_4_CLK_CYCLES),2 (STEPPER_SS_8_CLK_CYCLES),3 (STEPPER_SS_16_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_STEPPER_VS_CTL"
      sgroup "S5_CTRL_STEPPER_VS_CTL (at 0x12061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_STEPPER_EN                            = " "0 (STEPPER_EN_FALSE),1 (STEPPER_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VS_STEPPER_DELAY                         = " "0 (STEPPER_VS_2_CLK_CYCLES),1 (STEPPER_VS_4_CLK_CYCLES),2 (STEPPER_VS_8_CLK_CYCLES),3 (STEPPER_VS_16_CLK_CYCLES)"
    tree.end
    tree "S5_CTRL_QM_PS_EXIT"
      sgroup "S5_CTRL_QM_PS_EXIT (at 0x12063)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QM_MODE                                  = " "0 (QM_MODE_FORCE_PFM_DITHER_ENABLED),1 (QM_MODE_FORCED_PWM)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QM_FOLLOW                                = " "0 (FOLLOW_QM_FALSE),1 (FOLLOW_QM_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QM_PS_METHOD                             = " "0 (QMODE_PS_METHOD_ILOAD),1 (QMODE_PS_METHOD_ERRAMP)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QM_PS_VRST_RANGE                         = " "0 (QM_PS_VRST_RANGE_LOW),1 (QM_PS_VRST_RANGE_HIGH)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   QM_PS_VRST                               = " "0 (QM_PS_VRST_0MV),1 (QM_PS_VRST_VOUTDIV30),2 (QM_PS_VRST_VOUTDIV20),3 (QM_PS_VRST_VOUTDIV15),4 (QM_PS_VRST_VOUTDIV12),5 (QM_PS_VRST_VOUTDIV10),6 (QM_PS_VRST_VOUTDIV9),7 (QM_PS_VRST_VOUTDIV8)"
    tree.end
    tree "S5_CTRL_OCP"
      sgroup "S5_CTRL_OCP (at 0x12066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OCP_LATCH_EN                             = " "0 (OCP_LATCH_EN_FALSE),1 (OCP_LATCH_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VREG_FOLDBACK_EN                         = " "0 (FORCE_FOLDBACK_FALSE),1 (FORCE_FOLDBACK_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   INZERO_WAIT_OCP_TIMER                    = " "0 (INZERO_WAIT_40US_OCP_TIMER_320US),1 (INZERO_WAIT_80US_OCP_TIMER_640US),2 (INZERO_WAIT_160US_OCP_TIMER_1280_US),3 (INZERO_WAIT_160US_OCP_TIMER_1280US)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OCP_GLOBAL_BROADCAST_EN                  = " "0 (OCP_GLOBAL_BROADCAST_EN_FALSE),1 (OCP_GLOBAL_BROADCAST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_STATUS_CLEAR                         = " "0 (OCP_STATUS_CLEAR_FALSE),1 (OCP_STATUS_CLEAR_TRUE)"
    tree.end
    tree "S5_CTRL_ULS_VSET_LB"
      sgroup "S5_CTRL_ULS_VSET_LB (at 0x12068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VSET_LB                              = "
    tree.end
    tree "S5_CTRL_ULS_VSET_UB"
      sgroup "S5_CTRL_ULS_VSET_UB (at 0x12069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ULS_VSET_UB                              = "
    tree.end
    tree "S5_CTRL_STATUS_DEB_CTL"
      sgroup "S5_CTRL_STATUS_DEB_CTL (at 0x12070)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VREG_READY_DEB                           = " "0 (READY_DEB_0_LFRC_DIV2),1 (READY_DEB_1_LFRC_DIV4),2 (READY_DEB_2_LFRC_DIV8),3 (READY_DEB_3_LFRC_DIV16)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREG_ERROR_DEB                           = " "0 (ERROR_DEB_0_LFRC_DIV2),1 (ERROR_DEB_1_LFRC_DIV4),2 (ERROR_DEB_2_LFRC_DIV8),3 (ERROR_DEB_3_LFRC_DIV16)"
    tree.end
    tree "S5_CTRL_CAL_TIMER_CTL"
      sgroup "S5_CTRL_CAL_TIMER_CTL (at 0x12071)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CAL_TIMER                                = "
    tree.end
    tree "S5_CTRL_CAL_START"
      sgroup "S5_CTRL_CAL_START (at 0x12072)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQ_WR_PULSE                         = " "0 (CAL_REQ_WR_PULSE_FALSE),1 (CAL_REQ_WR_PULSE_TRUE)"
    tree.end
    tree "S5_CTRL_CAL_TRIM1"
      sgroup "S5_CTRL_CAL_TRIM1 (at 0x12073)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERR_AMP_TRIM_AUTO                        = "
    tree.end
    tree "S5_CTRL_CAL_TRIM2"
      sgroup "S5_CTRL_CAL_TRIM2 (at 0x12074)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM_AUTO                      = "
    tree.end
    tree "S5_CTRL_CAL_TRIM3"
      sgroup "S5_CTRL_CAL_TRIM3 (at 0x12075)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM_AUTO                       = "
    tree.end
    tree "S5_CTRL_CAL_TRIM4"
      sgroup "S5_CTRL_CAL_TRIM4 (at 0x12076)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM_AUTO                      = "
    tree.end
    tree "S5_CTRL_CAL_TRIM5"
      sgroup "S5_CTRL_CAL_TRIM5 (at 0x12077)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM_AUTO                  = "
    tree.end
    tree "S5_CTRL_CAL_TRIM_EN_CTL"
      sgroup "S5_CTRL_CAL_TRIM_EN_CTL (at 0x12078)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ERR_AMP_TRIM_CAL_EN                      = " "0 (reserved),1 (ERR_AMP_TRIM_CAL_EN_MAN),2 (reserved),3 (ERR_AMP_TRIM_CAL_EN_AUTO)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PWM_THRES_TRIM_CAL_EN                    = " "0 (PWM_THRES_TRIM_CAL_EN_MAN),1 (PWM_THRES_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_TRIM_CAL_EN                     = " "0 (PFM_COMP_TRIM_CAL_EN_MAN),1 (PFM_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VDIP_COMP_TRIM_CAL_EN                    = " "0 (VDIP_COMP_TRIM_CAL_EN_MAN),1 (VDIP_COMP_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PWM_RAMP_PEAK_TRIM_CAL_EN                = " "0 (PWM_RAMP_PEAK_TRIM_CAL_EN_MAN),1 (PWM_RAMP_PEAK_TRIM_CAL_EN_DIR)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_CAL_ENG_EN                          = " "0 (TRIM_CAL_ENG_EN_FALSE),1 (TRIM_CAL_ENG_EN_TRUE)"
    tree.end
    tree "S5_CTRL_CTLR_MISC"
      sgroup "S5_CTRL_CTLR_MISC (at 0x1207e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80207e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x207e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DIS_PFM_DIR_SAMPLE                       = " "0 (DIS_PFM_DIR_SAMPLE_FALSE),1 (DIS_PFM_DIR_SAMPLE_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIS_VDIP_HCPFM_GATE                      = " "0 (DIS_VDIP_HCPFM_GATE_FALSE),1 (DIS_VDIP_HCPFM_GATE_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_PRECH_EXTEND                         = " "0 (DIS_PRECH_EXTEND_FALSE),1 (DIS_PRECH_EXTEND_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIS_FORCE_PWM                            = " "0 (DIS_FORCE_PWM_FALSE),1 (DIS_FORCE_PWM_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DIS_CLAMP                                = " "0 (DIS_CLAMP_FALSE),1 (DIS_CLAMP_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_PS_TIMEOUT                           = " "0 (DIS_PS_TIMEOUT_FALSE),1 (DIS_PS_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIS_ERRAMP_TRIM_BUF                      = " "0 (DIS_ERRAMP_TRIM_BUF_FALSE),1 (DIS_ERRAMP_TRIM_BUF_TRUE)"
    tree.end
    tree "S5_CTRL_SCRATCH_REG"
      sgroup "S5_CTRL_SCRATCH_REG (at 0x1207f)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80207f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x207f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SCRATCH_7                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SCRATCH_6                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SCRATCH_5                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SCRATCH_4                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SCRATCH_3                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SCRATCH_2                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SCRATCH_1                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SCRATCH_0                                = " "0, 1"
    tree.end
    tree "S5_CTRL_GANG_CTL1"
      sgroup "S5_CTRL_GANG_CTL1 (at 0x120c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_CTRL_GANG_CTL2"
      sgroup "S5_CTRL_GANG_CTL2 (at 0x120c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANG_EN_FALSE),1 (GANG_EN_TRUE)"
    tree.end
    tree "S5_CTRL_SEC_ACCESS"
      sgroup "S5_CTRL_SEC_ACCESS (at 0x120d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL1"
      sgroup "S5_CTRL_PERPH_RESET_CTL1 (at 0x120d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL2"
      sgroup "S5_CTRL_PERPH_RESET_CTL2 (at 0x120d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL3"
      sgroup "S5_CTRL_PERPH_RESET_CTL3 (at 0x120da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL4"
      sgroup "S5_CTRL_PERPH_RESET_CTL4 (at 0x120db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_ACTIVE_FALSE),1 (LOCAL_SOFT_RESET_ACTIVE_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST1"
      sgroup "S5_CTRL_INT_TEST1 (at 0x120e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "S5_CTRL_INT_TEST_VAL"
      sgroup "S5_CTRL_INT_TEST_VAL (at 0x120e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREG_READY_INT_TEST_VAL                  = " "0 (VREG_READY_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_READY_INT_TEST_VAL_ACTIVE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT_INT_TEST_VAL                  = " "0 (VREG_FAULT_INT_TEST_VAL_ACTIVE_FALSE),1 (VREG_FAULT_INT_TEST_VAL_ACTIVE_TRUE)"
    tree.end
    tree "S5_CTRL_CTLR_TEST1"
      sgroup "S5_CTRL_CTLR_TEST1 (at 0x120e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_SEL_NORMAL_OPERATION),1 (ATEST1_SEL_ERR_AMP_OUT),2 (ATEST1_SEL_VREF_DAC),3 (ATEST1_SEL_VRAMP_PK),4 (ATEST1_SEL_VREF_RESET),5 (ATEST1_SEL_VRAMP),6 (ATEST1_SEL_VFB_DIV_PFM),7 (ATEST1_SEL_ERR_AMP_IN_MNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_SEL_NORMAL_OPERATION),1 (DTEST1_SEL_BUCK_CLK),2 (DTEST1_SEL_PS_COMP),3 (DTEST1_SEL_PULSE_SKIP_FSM),4 (DTEST1_SEL_PWM_COMP),5 (DTEST1_SEL_LO_COMP_FSM),6 (DTEST1_SEL_PFM_COMP_FSM),7 (DTEST1_SEL_MODE_FSM)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0 (TRIM_CALIB_EN_FALSE),1 (TRIM_CALIB_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_CTRL_CTLR_TEST2"
      sgroup "S5_CTRL_CTLR_TEST2 (at 0x120e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_SEL_NORMAL_OPERATION),1 (ATEST2_SEL_VREF_DAC_EA),2 (ATEST2_SEL_A_REG_GNDC),3 (ATEST2_SEL_VRAMP_BOT),4 (ATEST2_SEL_ERRAMP_OUT),5 (ATEST2_SEL_AVDD),6 (ATEST2_SEL_VFB_DIV_PSKIP),7 (ATEST2_SEL_VOUT_SNS)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_SEL_NORMAL_OPERATION),1 (DTEST2_SEL_CLK_LFRC),2 (DTEST2_SEL_INZ_CNT_DONE),3 (DTEST2_SEL_PDRV_EXTEND),4 (DTEST2_SEL_PS_EXIT),5 (DTEST2_SEL_PS_ENTER_WIN),6 (DTEST2_SEL_IPLIM_INT_MODE),7 (DTEST2_SEL_FORCE_PS_FOLDBACK)"
    tree.end
    tree "S5_CTRL_CTLR_TEST3"
      sgroup "S5_CTRL_CTLR_TEST3 (at 0x120e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST3_SEL                               = " "0 (DTEST3_SEL_NORMAL_OPERATION),1 (DTEST3_SEL_ERRAMP_DIG),2 (DTEST3_SEL_VRAMP_COMP_DIG),3 (DTEST3_SEL_PFM_COMP_CNTR),4 (DTEST3_SEL_VDIP_COMP),5 (DTEST3_SEL_TRIM_MUX_OUT),6 (DTEST3_SEL_CLAMP_ON),7 (DTEST3_SEL_RAMP_RST)"
    tree.end
    tree "S5_CTRL_TRIM_NUM"
      sgroup "S5_CTRL_TRIM_NUM (at 0x120f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_CTRL_CAL_MANUAL"
      sgroup "S5_CTRL_CAL_MANUAL (at 0x120f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MAN_CAL                                  = "
    tree.end
    tree "S5_CTRL_CTL_TRIM1"
      sgroup "S5_CTRL_CTL_TRIM1 (at 0x120f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_THRES_TRIM                           = "
    tree.end
    tree "S5_CTRL_CTL_TRIM2"
      sgroup "S5_CTRL_CTL_TRIM2 (at 0x120f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_COMP_TRIM                            = "
    tree.end
    tree "S5_CTRL_CTL_TRIM4"
      sgroup "S5_CTRL_CTL_TRIM4 (at 0x120f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S5_CTRL_CTL_TRIM3"
      sgroup "S5_CTRL_CTL_TRIM3 (at 0x120f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   PWM_RAMP_PEAK_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "S5_FREQ"
  tree "S5_FREQ"
    tree "S5_FREQ_REVISION1"
      sgroup "S5_FREQ_REVISION1 (at 0x12200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION2"
      sgroup "S5_FREQ_REVISION2 (at 0x12201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_FREQ_PERPH_TYPE"
      sgroup "S5_FREQ_PERPH_TYPE (at 0x12204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_FREQ_PERPH_SUBTYPE"
      sgroup "S5_FREQ_PERPH_SUBTYPE (at 0x12205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_FREQ_CLK_ENABLE"
      sgroup "S5_FREQ_CLK_ENABLE (at 0x12246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0 (FORCE_EN_DISABLED),1 (FORCE_EN_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0 (FALLOW_CLK_REQ_DISABLED),1 (FALLOW_CLK_REQ_ENABLED)"
    tree.end
    tree "S5_FREQ_CLK_DIV"
      sgroup "S5_FREQ_CLK_DIV (at 0x12250)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S5_FREQ_CLK_PHASE"
      sgroup "S5_FREQ_CLK_PHASE (at 0x12251)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S5_FREQ_GANG_CTL1"
      sgroup "S5_FREQ_GANG_CTL1 (at 0x122c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_FREQ_GANG_CTL2"
      sgroup "S5_FREQ_GANG_CTL2 (at 0x122c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0 (GANGING_DISABLED),1 (GANGING_ENABLED)"
    tree.end
    tree "S5_FREQ_SEC_ACCESS"
      sgroup "S5_FREQ_SEC_ACCESS (at 0x122d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL2"
      sgroup "S5_FREQ_PERPH_RESET_CTL2 (at 0x122d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL3"
      sgroup "S5_FREQ_PERPH_RESET_CTL3 (at 0x122da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL4"
      sgroup "S5_FREQ_PERPH_RESET_CTL4 (at 0x122db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "S5_FREQ_TEST1"
      sgroup "S5_FREQ_TEST1 (at 0x122e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST_SEL                                = " "0 (DRIVE_DTEST1),1 (DRIVE_DTEST2),2 (DRIVE_DTEST3),3 (DRIVE_DTEST4)"
    tree.end
  tree.end
tree.end
tree "S5_PS"
  tree "S5_PS"
    tree "S5_PS_REVISION1"
      sgroup "S5_PS_REVISION1 (at 0x12100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION2"
      sgroup "S5_PS_REVISION2 (at 0x12101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_PS_REVISION3"
      sgroup "S5_PS_REVISION3 (at 0x12102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION4"
      sgroup "S5_PS_REVISION4 (at 0x12103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_PS_PERPH_TYPE"
      sgroup "S5_PS_PERPH_TYPE (at 0x12104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_PS_PERPH_SUBTYPE"
      sgroup "S5_PS_PERPH_SUBTYPE (at 0x12105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_PS_STATUS3"
      sgroup "S5_PS_STATUS3 (at 0x1210a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80210a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x210a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_COMP_STATE                           = " "0 (CAL_COMP_STATE_FALSE),1 (CAL_COMP_STATE_TRUE)"
    tree.end
    tree "S5_PS_STATUS4"
      sgroup "S5_PS_STATUS4 (at 0x1210b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80210b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x210b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_DATA_OVERWRITTEN                     = " "0 (ECM_MISSED_DATA_FALSE),1 (ECM_MISSED_DATA_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   ECM_DATA_TYPE                            = " "0 (ECM_DATA_TYPE_MEASUREMENT),1 (ECM_DATA_TYPE_REFERENCE),2 (ECM_DATA_TYPE_OFFSET),3 (ECM_DATA_TYPE_RESERVED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ECM_PRESENT                              = " "0 (ECM_PRESENT_FALSE),1 (ECM_PRESENT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ECM_DATA_READY                           = " "0 (ECM_DATA_READY_FALSE),1 (ECM_DATA_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ECM_REQ_SW_CALIB                         = " "0 (ECM_REQ_SW_CALIB_FALSE),1 (ECM_REQ_SW_CALIB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ECM_READY                                = " "0 (ECM_READY_FALSE),1 (ECM_READY_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ECM_DATA_NEGATIVE                        = " "0 (ECM_DATA_NEGATIVE_FALSE),1 (ECM_DATA_NEGATIVE_TRUE)"
    tree.end
    tree "S5_PS_PFM_FREQ_CTL"
      sgroup "S5_PS_PFM_FREQ_CTL (at 0x12144)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_FREQ_DITH_EN                         = " "0 (PFM_DITHERING_EN_FALSE),1 (PFM_DITHERING_EN_TRUE)"
    tree.end
    tree "S5_PS_PFM_FREQ_CFG"
      sgroup "S5_PS_PFM_FREQ_CFG (at 0x12145)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FREQ_DITH_NUMBIT_SEL                     = " "0 (NUMBIT_SEL_2B),1 (NUMBIT_SEL_3B)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DITH_TIMING_CTL                          = " "0 (DITH_CTL_PFM_COMP_CLK),1 (DITH_CTL_PFM_COMP_DIV4_CLK),2 (DITH_CTL_PFM_COMP_DIV32_CLK),3 (DITH_CTL_PFM_COMP_DIV128_CLK),4 (DITH_CTL_LFRC_CLK),5 (DITH_CTL_LFRC_DIV4_CLK),6 (DITH_CTL_LFRC_DIV32_CLK),7 (DITH_CTL_LFRC_DIV128_CLK)"
    tree.end
    tree "S5_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S5_PS_PWM_CURRENT_LIM_CTL (at 0x1214a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80214a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x214a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CURRENT_LIM_AUTOINT_SEL                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PWM_SEL                      = "
    tree.end
    tree "S5_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S5_PS_PFM_CURRENT_LIM_CTL (at 0x1214b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80214b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x214b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_PWM_CURRENT_LIM_EN                   = " "0 (CURRENT_LIM_EN_FALSE),1 (CURRENT_LIM_EN_TRUE)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CURRENT_LIM_PFM_SEL                      = "
    tree.end
    tree "S5_PS_ILIM_SS_CTL"
      sgroup "S5_PS_ILIM_SS_CTL (at 0x1214c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80214c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x214c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ILIM_SS_SEL                              = "
    tree.end
    tree "S5_PS_ISNS_THRES"
      sgroup "S5_PS_ISNS_THRES (at 0x1215a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80215a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x215a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_ENTRY_AUTO                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PS_ENTRY_PWM                             = "
    tree.end
    tree "S5_PS_QM_PS_ENTRY"
      sgroup "S5_PS_QM_PS_ENTRY (at 0x12163)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_ENTRY                           = "
    tree.end
    tree "S5_PS_SWITCH_SIZE_CTL"
      sgroup "S5_PS_SWITCH_SIZE_CTL (at 0x12170)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   P_SWITCH_SIZE                            = " "0 (P_SWITCH_SIZE_1_MIN),1 (P_SWITCH_SIZE_1_DIV_4),2 (P_SWITCH_SIZE_1_DIV_2),3 (P_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   N_SWITCH_SIZE                            = " "0 (N_SWITCH_SIZE_1_MIN),1 (N_SWITCH_SIZE_1_DIV_4),2 (N_SWITCH_SIZE_1_DIV_2),3 (N_SWITCH_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   P_OFF_DRIVER_SIZE                        = " "0 (P_OFF_DRIVER_SIZE_1_DIV_2),1 (P_OFF_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   P_ON_DRIVER_SIZE                         = " "0 (P_ON_DRIVER_SIZE_1_DIV_2),1 (P_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   N_ON_DRIVER_SIZE                         = " "0 (N_ON_DRIVER_SIZE_1_DIV_2),1 (N_ON_DRIVER_SIZE_1_DIV_1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_OFF_DRIVER_SIZE                        = " "0 (N_OFF_DRIVER_SIZE_1_DIV_2),1 (N_OFF_DRIVER_SIZE_1_DIV_1)"
    tree.end
    tree "S5_PS_DEAD_TIME_CTRL"
      sgroup "S5_PS_DEAD_TIME_CTRL (at 0x12172)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0 (NSW_DEAD_TIME_1P5_NS),1 (NSW_DEAD_TIME_2P4_NS),2 (NSW_DEAD_TIME_3P3_NS),3 (NSW_DEAD_TIME_4P4_NS)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0 (PSW_DEAD_TIME_2P0_NS),1 (PSW_DEAD_TIME_2P4_NS),2 (PSW_DEAD_TIME_3P2_NS),3 (PSW_DEAD_TIME_4P4_NS)"
    tree.end
    tree "S5_PS_BLNK_TIME_CTL"
      sgroup "S5_PS_BLNK_TIME_CTL (at 0x12173)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0 (MIN_PON_DISABLED),1 (MIN_PON_15NS_OR_25NS),2 (MIN_PON_40NS_OR_50NS),3 (MIN_PON_60NS_OR_70NS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0 (ISNS_BLNK_TIME_15NS),1 (ISNS_BLNK_TIME_25NS)"
    tree.end
    tree "S5_PS_INZERO_CTL"
      sgroup "S5_PS_INZERO_CTL (at 0x12174)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0 (INZERO_EN_FALSE),1 (INZERO_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0 (INZERO_OFFSET_NO_OFFSET),1 (INZERO_OFFSET_NEG_3MV),2 (INZERO_OFFSET_POS_1P5MV),3 (INZERO_OFFSET_POS_3MV)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0 (INZERO_FORCE_DISABLE),1 (INZERO_FORCE_ENABLE)"
    tree.end
    tree "S5_PS_DIG_FSM_CTL"
      sgroup "S5_PS_DIG_FSM_CTL (at 0x12175)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_LAT_DIS                              = " "0 (FSM_DISABLE_LATCH_FALSE),1 (FSM_DISABLE_LATCH_TRUE)"
    tree.end
    tree "S5_PS_CAL_EN_CTL1"
      sgroup "S5_PS_CAL_EN_CTL1 (at 0x12178)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   IPLIM_TRIM_CAL_EN                        = " "0 (IPLIM_TRIM_CAL_EN_FALSE),1 (IPLIM_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_THRES_TRIM_CAL_EN                   = " "0 (AUTO_THRES_TRIM_CAL_EN_FALSE),1 (AUTO_THRES_TRIM_CAL_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INZERO_TRIM_CAL_EN                       = " "0 (INZERO_TRIM_CAL_EN_FALSE),1 (INZERO_TRIM_CAL_EN_TRUE)"
    tree.end
    tree "S5_PS_PWR_STG_MISC"
      sgroup "S5_PS_PWR_STG_MISC (at 0x1217e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0 (DUTY_EST_CLK_SEL_BIT1_FALSE),1 (DUTY_EST_CLK_SEL_BIT1_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0 (DUTY_EST_CLK_SEL_BIT0_FALSE),1 (DUTY_EST_CLK_SEL_BIT0_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0 (AUTO_BLOCK_THRESH_NORMAL),1 (AUTO_BLOCK_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0 (PFM_CURRENT_LIMIT_THRESH_NORMAL),1 (PFM_CURRENT_LIMIT_THRESH_HALF)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0 (AUTO_MODE_BW_SEL_NORMAL),1 (AUTO_MODE_BW_SEL_QUARTER)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0 (BYPASS_CMN_MODE_ECM_FALSE),1 (BYPASS_CMN_MODE_ECM_TRUE)"
    tree.end
    tree "S5_PS_ECM_EN_CTL"
      sgroup "S5_PS_ECM_EN_CTL (at 0x12180)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_LOCAL_EN                             = " "0 (ECM_LOCAL_EN_FALSE),1 (ECM_LOCAL_EN_TRUE)"
    tree.end
    tree "S5_PS_ECM_CFG_0"
      sgroup "S5_PS_ECM_CFG_0 (at 0x12181)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SENSE_SW_NTWK_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   FET_REF_SIZE_SEL                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_ADC_REF_CHOPPING                      = " "0 (EN_ADC_REF_CHOPPING_FALSE),1 (EN_ADC_REF_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_ADC_IN_CHOPPING                       = " "0 (EN_ADC_IN_CHOPPING_FALSE),1 (EN_ADC_IN_CHOPPING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SENSE_FILT_BW_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ADC_GAIN_SEL                             = " "0 (ADC_GAIN_SEL_GAIN_OF_2),1 (ADC_GAIN_SEL_GAIN_OF_3),2 (ADC_GAIN_SEL_GAIN_OF_3P0),3 (ADC_GAIN_SEL_GAIN_OF_4)"
    tree.end
    tree "S5_PS_ECM_CFG_1"
      sgroup "S5_PS_ECM_CFG_1 (at 0x12182)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   ECM_BIAS_CTRL                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ECM_REF_OFF_CTRL                         = " "0 (ECM_REF_OFF_CTRL_0),1 (ECM_REF_OFF_CTRL_1),2 (ECM_REF_OFF_CTRL_2),3 (ECM_REF_OFF_CTRL_3),4 (ECM_REF_OFF_CTRL_4),5 (ECM_REF_OFF_CTRL_5),6 (ECM_REF_OFF_CTRL_6),7 (ECM_REF_OFF_CTRL_7)"
    tree.end
    tree "S5_PS_ECM_DATA_LB"
      sgroup "S5_PS_ECM_DATA_LB (at 0x12184)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_LB                              = "
    tree.end
    tree "S5_PS_ECM_DATA_UB"
      sgroup "S5_PS_ECM_DATA_UB (at 0x12185)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ECM_DATA_UB                              = "
    tree.end
    tree "S5_PS_SEC_ACCESS"
      sgroup "S5_PS_SEC_ACCESS (at 0x121d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_PS_PERPH_RESET_CTL2"
      sgroup "S5_PS_PERPH_RESET_CTL2 (at 0x121d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RB_FALSE),1 (FOLLOW_GLOBAL_SOFT_RB_TRUE)"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL3"
      sgroup "S5_PS_PERPH_RESET_CTL3 (at 0x121da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL4"
      sgroup "S5_PS_PERPH_RESET_CTL4 (at 0x121db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "S5_PS_FORCE_FET_TEST"
      sgroup "S5_PS_FORCE_FET_TEST (at 0x121e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0 (KELVIN_SENSING_TEST_NMOS_RON),1 (KELVIN_SENSING_TEST_PMOS_RON)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0 (FORCE_PFET_NFET_NORMAL),1 (FORCE_PFET_NFET_NMOS_ON_PMOS_OFF),2 (FORCE_PFET_NFET_PMOS_ON_NMOS_OFF),3 (FORCE_BOTH_PMOS_NMOS_OFF)"
    tree.end
    tree "S5_PS_PWR_STG_TEST1"
      sgroup "S5_PS_PWR_STG_TEST1 (at 0x121e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST1_SEL                               = " "0 (ATEST1_NORMAL),1 (ATEST1_FET_KSP1),2 (ATEST1_REF_KSP1),3 (ATEST1_ECM_OUT_CM),4 (ATEST1_A_ECM_ATEST_FORCE1),5 (ATEST1_VREF_FILT),6 (ATEST1_VREF_SNS),7 (ATEST1_FLOATING)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST1_SEL                               = " "0 (DTEST1_MISSION_MODE),1 (DTEST1_D_AUTO_PS_THRES_COMP),2 (DTEST1_D_DC_VOUT_CLK_1),3 (DTEST1_D_PSW_DRV_SEL),4 (DTEST1_D_INZ_COMP_LOC),5 (DTEST1_D_IPLIM_COMP_LOC),6 (DTEST1_ECM_PHI1),7 (DTEST1_D_NSW_DRV_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OPEN_LOOP_TEST_EN                        = " "0 (OPEN_LOOP_TEST_EN_FALSE),1 (OPEN_LOOP_TEST_EN_TRUE)"
    tree.end
    tree "S5_PS_PWR_STG_TEST2"
      sgroup "S5_PS_PWR_STG_TEST2 (at 0x121e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST2_SEL                               = " "0 (ATEST2_MISSION_MODE),1 (ATEST2_FET_KSP2),2 (ATEST2_REF_KSP2),3 (ATEST2_ECM_VBIAS),4 (ATEST2_A_ECM_ATEST_FORCE2),5 (ATEST2_VSW_FILT),6 (ATEST2_VSW_SNS),7 (ATEST2_SPARE)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST2_SEL                               = " "0 (DTEST2_MISSION_MODE),1 (DTEST2_D_END_MIN_PON),2 (DTEST2_D_DC_COMP_OUT),3 (DTEST2_D_PFM_ENTRY_BUF),4 (DTEST2_D_INZ_COMP_EXTEND),5 (DTEST2_D_PGATE_BLNK),6 (DTEST2_ECM_PHI2),7 (DTEST2_D_PSK_ENTRY_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   IPLIM_TEST_CTRL                          = " "0 (IPLIM_TEST_MODE_CTRL_RESERVED_0),1 (IPLIM_TEST_MODE_CTRL_RESERVED_1),2 (IPLIM_TEST_MODE_CTRL_RESERVED_2),3 (IPLIM_TEST_MODE_CTRL_RESERVED_3)"
    tree.end
    tree "S5_PS_PWR_STG_TEST3"
      sgroup "S5_PS_PWR_STG_TEST3 (at 0x121e6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST3_SEL                               = " "0 (DTEST3_MISSION_MODE),1 (DTEST3_D_D2A_ECM_DTEST_DEC_0_D_D2A_ECM_ADC_INPUT_POLARITY),2 (DTEST3_D_D2A_ECM_DTEST_DEC_2_D_D2A_ECM_ADC_INPUT_MUX_CTRL_1),3 (DTEST3_D_D2A_ECM_DTEST_DEC_4_D_CHOP_SYNC),4 (DTEST3_D_D2A_ECM_DTEST_DEC_6_D_CAL_STROBE),5 (DTEST3_CAL_MUX_FILT_OUT),6 (DTEST3_ECM_COMP_P),7 (DTEST3_ECM_COMP_N)"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST4_SEL                               = " "0 (DTEST4_MISSION_MODE),1 (DTEST4_D_D2A_ECM_DTEST_DEC_1_D_D2A_ECM_ADC_INPUT_MUX_CTRL_0),2 (DTEST4_D_D2A_ECM_DTEST_DEC_3_D_D2A_ECM_ADC_INPUT_MUX_CTRL_2),3 (DTEST4_D_D2A_ECM_DTEST_DEC_5_D_GLOBAL_EN),4 (DTEST4_D_D2A_ECM_DTEST_DEC_7_D_STROBE),5 (DTEST4_SPARE),6 (DTEST4_ECM_ADC_INPUT_POLARITY),7 (DTEST4_D_ADC_CLR)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_SENSE                                 = " "0 (EN_SENSE_FALSE),1 (EN_SENSE_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_ADC                                   = " "0 (EN_ADC_FALSE),1 (EN_ADC_TRUE)"
    tree.end
    tree "S5_PS_PWR_STG_TEST4"
      sgroup "S5_PS_PWR_STG_TEST4 (at 0x121e7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ECM_TEST_EN                              = " "0 (ECM_TEST_EN_FALSE),1 (ECM_TEST_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ECM_INPUT_MUX_CTRL                       = " "0 (ECM_INPUT_MUX_CTRL_0),1 (ECM_INPUT_MUX_CTRL_1),2 (ECM_INPUT_MUX_CTRL_2),3 (ECM_INPUT_MUX_CTRL_3),4 (ECM_INPUT_MUX_CTRL_4),5 (ECM_INPUT_MUX_CTRL_5),6 (ECM_INPUT_MUX_CTRL_6),7 (ECM_INPUT_MUX_CTRL_7)"
    tree.end
    tree "S5_PS_TRIM_NUM"
      sgroup "S5_PS_TRIM_NUM (at 0x121f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S5_PS_PS_TRIM1"
      sgroup "S5_PS_PS_TRIM1 (at 0x121f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   IPLIM_TRIM                               = "
    tree.end
    tree "S5_PS_PS_TRIM2"
      sgroup "S5_PS_PS_TRIM2 (at 0x121f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S5_PS_PS_TRIM3"
      sgroup "S5_PS_PS_TRIM3 (at 0x121f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AUTO_THRS_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "SLEEP_CLK1"
  tree "SLEEP_CLK1"
    tree "SLEEP_CLK1_REVISION1"
      sgroup "SLEEP_CLK1_REVISION1 (at 0x5a00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SLEEP_CLK1_REVISION2"
      sgroup "SLEEP_CLK1_REVISION2 (at 0x5a01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SLEEP_CLK1_PERPH_TYPE"
      sgroup "SLEEP_CLK1_PERPH_TYPE (at 0x5a04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SLEEP_CLK1_PERPH_SUBTYPE"
      sgroup "SLEEP_CLK1_PERPH_SUBTYPE (at 0x5a05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SLEEP_CLK1_STATUS1"
      sgroup "SLEEP_CLK1_STATUS1 (at 0x5a08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SLP_CLK_OK                               = " "0 (SLP_CLK_BUFFER_OFF),1 (SLP_CLK_BUFFER_ON)"
    tree.end
    tree "SLEEP_CLK1_DRV_CTL1"
      sgroup "SLEEP_CLK1_DRV_CTL1 (at 0x5a44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_DRV                                  = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "SLEEP_CLK1_EDGE_CTL"
      sgroup "SLEEP_CLK1_EDGE_CTL (at 0x5a45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUT_EDGE                                 = " "0 (ONE_X),1 (TWO_X),2 (THREE_X),3 (FOUR_X)"
    tree.end
    tree "SLEEP_CLK1_EN_CTL"
      sgroup "SLEEP_CLK1_EN_CTL (at 0x5a46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_SLPCLK_PAD_EN                      = " "0 (NOT_FORCE_SLPCLK_PAD_EN),1 (FORCE_SLPCLK_PAD_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLOW_HW_SLPCLK_PAD_EN                   = " "0 (NOT_FOLLOW_HW_SLPCLK_PAD_EN),1 (FOLLOW_HW_SLPCLK_PAD_EN)"
    tree.end
    tree "SLEEP_CLK1_SLPSRC_CTL1"
      sgroup "SLEEP_CLK1_SLPSRC_CTL1 (at 0x5a49)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EXT32K_EN                                = " "0 (EXT32K_DISABLED),1 (EXT32K_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC1"
      sgroup "SLEEP_CLK1_CAL_RC1 (at 0x5a58)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CAL_FREQ_RTC_DEFAULT                     = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC2"
      sgroup "SLEEP_CLK1_CAL_RC2 (at 0x5a59)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DRIFT_LMT_RTC                            = "
    tree.end
    tree "SLEEP_CLK1_CAL_RC3"
      sgroup "SLEEP_CLK1_CAL_RC3 (at 0x5a5a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LFRC_DRIFT_DET_EN_BATT                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC4"
      sgroup "SLEEP_CLK1_CAL_RC4 (at 0x5a5b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CALRC_EN                                 = " "0 (CALRC_DISABLED),1 (CALRC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   COINCELL_GOOD                            = " "0 (WEAK_COINCAP),1 (STRONG_COINCAP)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LFRC_DRIFT_DET_EN_COIN                   = " "0 (DRIFT_DET_DISABLED),1 (DRIFT_DET_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CALRC_DTEST_EN                           = " "0 (NORMAL),1 (CALRC_STATE_ON_DTEST)"
    tree.end
    tree "SLEEP_CLK1_CAL_RC5"
      sgroup "SLEEP_CLK1_CAL_RC5 (at 0x5a5c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805a5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MIN_XO_COUNT_LMT                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MAX_XO_COUNT_LMT                         = "
    tree.end
    tree "SLEEP_CLK1_SEC_ACCESS"
      sgroup "SLEEP_CLK1_SEC_ACCESS (at 0x5ad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL1"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL1 (at 0x5ad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL2"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL2 (at 0x5ad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL3"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL3 (at 0x5ada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL4"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL4 (at 0x5adb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL5"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL5 (at 0x5adc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805adc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5adc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SLEEP_CLK1_PERPH_RESET_CTL6"
      sgroup "SLEEP_CLK1_PERPH_RESET_CTL6 (at 0x5add)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805add0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5add0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "SLEEP_CLK1_TEST1"
      sgroup "SLEEP_CLK1_TEST1 (at 0x5ae2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        set &access:&cmd_addr %l 0x805ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OSC_VDD_ATEST_EN                         = " "0 (HIZ),1 (CONNECT_TO_ATEST)"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SSC_DETECT_CFG"
      sgroup "SPMI_SSC_DETECT_CFG (at 0x641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SSC_DETECT_CFG                           = " "0 (WINDOW_DISABLED_Q1_DELAY_ENABLED),1 (WINDOW_DISABLED_Q1_DELAY_DISABLED),2 (WINDOW_ENABLED_Q1_DELAY_ENABLED),3 (WINDOW_ENABLED_Q1_DELAY_DISABLED),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      sgroup "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      sgroup "TEMP_ALARM_REVISION1 (at 0x2400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      sgroup "TEMP_ALARM_REVISION2 (at 0x2401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      sgroup "TEMP_ALARM_REVISION3 (at 0x2402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      sgroup "TEMP_ALARM_REVISION4 (at 0x2403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      sgroup "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      sgroup "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      sgroup "TEMP_ALARM_STATUS1 (at 0x2408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   TEMP_ALARM_FSM_STATE                     = " "0 (STATE_0),1 (STATE_1A),2 (STATE_1B),3 (STATE_2A),4 (STATE_2B),5 (STATE_3),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST3_EVENT_OCCURRED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0 (NO_EVENT),1 (ST2_EVENT_OCCURRED)"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      sgroup "TEMP_ALARM_INT_RT_STS (at 0x2410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0 (INT_RT_STATUS_LOW),1 (INT_RT_STATUS_HIGH)"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      sgroup "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      sgroup "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      sgroup "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      sgroup "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      sgroup "TEMP_ALARM_INT_EN_SET (at 0x2415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      sgroup "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      sgroup "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      sgroup "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      sgroup "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      sgroup "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0 (NO_ST3_OVERRIDE),1 (OVERTEMP_ST3_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0 (NO_ST2_OVERRIDE),1 (OVERTEMP_ST2_SHUTDOWN_BLOCKED)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TEMP_ALARM_CLK_RATE                      = " "0 (TEMP_ALARM_CLK_RATE_0),1 (TEMP_ALARM_CLK_RATE_1),2 (TEMP_ALARM_CLK_RATE_2),3 (TEMP_ALARM_CLK_RATE_3)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0 (THRESH_105C_125C_145C),1 (THRESH_110C_130C_150C),2 (THRESH_115C_135C_155C),3 (THRESH_120C_140C_160C)"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      sgroup "TEMP_ALARM_EN_CTL1 (at 0x2446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0 (TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FORCED_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0 (FOLLOW_HW_TEMP_ALARM_DISABLED),1 (TEMP_ALARM_FOLLOWS_HW_EN)"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      sgroup "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      sgroup "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      sgroup "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      sgroup "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
  tree.end
tree.end
tree "VADC_HM10_CMN"
  tree "VADC_HM10_CMN"
    tree "VADC_HM10_CMN_REVISION1"
      sgroup "VADC_HM10_CMN_REVISION1 (at 0x3900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC_HM10_CMN_REVISION2"
      sgroup "VADC_HM10_CMN_REVISION2 (at 0x3901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC_HM10_CMN_REVISION3"
      sgroup "VADC_HM10_CMN_REVISION3 (at 0x3902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC_HM10_CMN_REVISION4"
      sgroup "VADC_HM10_CMN_REVISION4 (at 0x3903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC_HM10_CMN_PERPH_TYPE"
      sgroup "VADC_HM10_CMN_PERPH_TYPE (at 0x3904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC_HM10_CMN_PERPH_SUBTYPE"
      sgroup "VADC_HM10_CMN_PERPH_SUBTYPE (at 0x3905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC_HM10_CMN_STATUS1"
      sgroup "VADC_HM10_CMN_STATUS1 (at 0x3908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_FSM                                 = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INFRASTRUCTURE_FAULT                     = " "0 (NO_INFRASTRUCTURE_FAULT),1 (INFRASTRUCTURE_FAULT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_FAULT                               = " "0 (NO_VREG_FAULT),1 (VREG_FAULT)"
    tree.end
    tree "VADC_HM10_CMN_SEC_ACCESS"
      sgroup "VADC_HM10_CMN_SEC_ACCESS (at 0x39d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC_HM10_CMN_PERPH_RESET_CTL2"
      sgroup "VADC_HM10_CMN_PERPH_RESET_CTL2 (at 0x39d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM10_CMN_PERPH_RESET_CTL3"
      sgroup "VADC_HM10_CMN_PERPH_RESET_CTL3 (at 0x39da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC_HM10_CMN_PERPH_RESET_CTL4"
      sgroup "VADC_HM10_CMN_PERPH_RESET_CTL4 (at 0x39db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM10_CMN_TEST1_ADC_ANA_PARAM"
      sgroup "VADC_HM10_CMN_TEST1_ADC_ANA_PARAM (at 0x39e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CAL_EN                                   = " "0 (OL_DIS),1 (OL_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_EN                                  = " "0 (AMUX_DISABLED),1 (AMUX_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC_HM10_CMN_TEST2_ADC_ANA_PARAM"
      sgroup "VADC_HM10_CMN_TEST2_ADC_ANA_PARAM (at 0x39e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VICM_0P60),1 (VICM_0P65),2 (VICM_0P70),3 (VICM_0P75)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BUFF_BYPASS_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REF_GND_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_GND_SEL                               = " "0, 1"
    tree.end
    tree "VADC_HM10_CMN_TRIM_PROC_PU1"
      sgroup "VADC_HM10_CMN_TRIM_PROC_PU1 (at 0x39e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MUX                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_PROC_PU1                            = "
    tree.end
    tree "VADC_HM10_CMN_TRIM_PROC_PU2"
      sgroup "VADC_HM10_CMN_TRIM_PROC_PU2 (at 0x39e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MUX                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_PROC_PU2                            = "
    tree.end
    tree "VADC_HM10_CMN_TRIM_PROC_PU3"
      sgroup "VADC_HM10_CMN_TRIM_PROC_PU3 (at 0x39e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_MUX                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_PROC_PU3                            = "
    tree.end
    tree "VADC_HM10_CMN_ATEST_MUX"
      sgroup "VADC_HM10_CMN_ATEST_MUX (at 0x39e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_VBAT_TEST                             = " "0 (BATT_TEST_DISABLED),1 (BATT_TEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_LDO_TEST                              = " "0 (LDO_TEST_DISABLED),1 (LDO_TEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_ADC_TEST                              = " "0 (ADC_TEST_DISABLED),1 (ADC_TEST_ENABLED)"
    tree.end
    tree "VADC_HM10_CMN_ATEST_CTL"
      sgroup "VADC_HM10_CMN_ATEST_CTL (at 0x39e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   ADC_ATEST_SEL                            = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATT_ATEST_SEL                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "VADC_HM10_CMN_SMIC_EN"
      sgroup "VADC_HM10_CMN_SMIC_EN (at 0x39ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SMIC_EN_PU1                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMIC_EN_PU2                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMIC_EN_PU3                              = " "0, 1"
    tree.end
    tree "VADC_HM10_CMN_TEST_VADC_LDO_CTL"
      sgroup "VADC_HM10_CMN_TEST_VADC_LDO_CTL (at 0x39eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VADC_LDO_EN                              = " "0 (VADC_LDO_DIS),1 (VADC_LDO_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   VADC_LDO_TIMER                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_TIMER_EXP                          = " "0, 1"
    tree.end
    tree "VADC_HM10_CMN_DTEST_CTL1"
      sgroup "VADC_HM10_CMN_DTEST_CTL1 (at 0x39ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "VADC_HM10_CMN_DTEST_CTL2"
      sgroup "VADC_HM10_CMN_DTEST_CTL2 (at 0x39ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "VADC_HM10_CMN_TEST3_ADC_DIG_PARAM"
      sgroup "VADC_HM10_CMN_TEST3_ADC_DIG_PARAM (at 0x39ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHOPPER_EN                               = " "0 (CHOPPER_DISABLED),1 (CHOPPER_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   CHOPPER_CLK_SEL                          = " "0 (ADC_CLKDIVBY128),1 (ADC_CLKDIVBY64),2 (ADC_CLKDIVBY32),3 (ADC_CLKDIVBY16)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   ADC_CLK_SEL                              = " "0 (ADC_CLK2P4M),1 (ADC_CLK4P8M),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN_MODE                            = " "0 (MISSION_LIKE),1 (FREE_RUNNING)"
    tree.end
    tree "VADC_HM10_CMN_TEST4_ADC_DIG_PARAM"
      sgroup "VADC_HM10_CMN_TEST4_ADC_DIG_PARAM (at 0x39ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIG_BOOST_METHOD                         = " "0 (LONG_DEC_RATIO),1 (LESS_SHIFT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DIG_BOOST_EN                             = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "VADC_HM10_CMN_TRIM_NUM"
      sgroup "VADC_HM10_CMN_TRIM_NUM (at 0x39f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC_HM10_CMN_TRIM_PU1"
      sgroup "VADC_HM10_CMN_TRIM_PU1 (at 0x39f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_PU1                                 = "
    tree.end
    tree "VADC_HM10_CMN_TRIM_PU2"
      sgroup "VADC_HM10_CMN_TRIM_PU2 (at 0x39f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_PU2                                 = "
    tree.end
    tree "VADC_HM10_CMN_TRIM_PU3"
      sgroup "VADC_HM10_CMN_TRIM_PU3 (at 0x39f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TRIM_PU3                                 = "
    tree.end
    tree "VADC_HM10_CMN_TRIM_AMUX_DIVBY3"
      sgroup "VADC_HM10_CMN_TRIM_AMUX_DIVBY3 (at 0x39f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        set &access:&cmd_addr %l 0x8039f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x39f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
  tree.end
tree.end
tree "VADC_HM1_USR"
  tree "VADC_HM1_USR"
    tree "VADC_HM1_USR_REVISION1"
      sgroup "VADC_HM1_USR_REVISION1 (at 0x3100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC_HM1_USR_REVISION2"
      sgroup "VADC_HM1_USR_REVISION2 (at 0x3101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC_HM1_USR_REVISION3"
      sgroup "VADC_HM1_USR_REVISION3 (at 0x3102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC_HM1_USR_REVISION4"
      sgroup "VADC_HM1_USR_REVISION4 (at 0x3103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC_HM1_USR_PERPH_TYPE"
      sgroup "VADC_HM1_USR_PERPH_TYPE (at 0x3104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC_HM1_USR_PERPH_SUBTYPE"
      sgroup "VADC_HM1_USR_PERPH_SUBTYPE (at 0x3105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC_HM1_USR_STATUS1"
      sgroup "VADC_HM1_USR_STATUS1 (at 0x3108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC_HM1_USR_INT_RT_STS"
      sgroup "VADC_HM1_USR_INT_RT_STS (at 0x3110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_THR_INT_RT_STS                  = " "0 (VBAT_MIN_THR_INT_FALSE),1 (VBAT_MIN_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC_HM1_USR_INT_SET_TYPE"
      sgroup "VADC_HM1_USR_INT_SET_TYPE (at 0x3111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_THR_INT_TYPE                    = " "0 (VBAT_MIN_THR_LEVEL),1 (VBAT_MIN_THR_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC_HM1_USR_INT_POLARITY_HIGH"
      sgroup "VADC_HM1_USR_INT_POLARITY_HIGH (at 0x3112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_HIGH                        = " "0 (VBAT_MIN_INT_POL_HIGH_DISABLED),1 (VBAT_MIN_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC_HM1_USR_INT_POLARITY_LOW"
      sgroup "VADC_HM1_USR_INT_POLARITY_LOW (at 0x3113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_LOW                         = " "0 (VBAT_MIN_INT_POL_LOW_DISABLED),1 (VBAT_MIN_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC_HM1_USR_INT_LATCHED_CLR"
      sgroup "VADC_HM1_USR_INT_LATCHED_CLR (at 0x3114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC_HM1_USR_INT_EN_SET"
      sgroup "VADC_HM1_USR_INT_EN_SET (at 0x3115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_EN_SET                      = " "0 (VBAT_MIN_INT_DISABLED),1 (VBAT_MIN_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM1_USR_INT_EN_CLR"
      sgroup "VADC_HM1_USR_INT_EN_CLR (at 0x3116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_EN_CLR                      = " "0 (VBAT_MIN_INT_DISABLED),1 (VBAT_MIN_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM1_USR_INT_LATCHED_STS"
      sgroup "VADC_HM1_USR_INT_LATCHED_STS (at 0x3118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_LATCHED_STS                 = " "0 (VBAT_MIN_INT_LATCHED_FALSE),1 (VBAT_MIN_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC_HM1_USR_INT_PENDING_STS"
      sgroup "VADC_HM1_USR_INT_PENDING_STS (at 0x3119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_PENDING_STS                 = " "0 (VBAT_MIN_INT_PENDING_FALSE),1 (VBAT_MIN_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC_HM1_USR_INT_MID_SEL"
      sgroup "VADC_HM1_USR_INT_MID_SEL (at 0x311a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC_HM1_USR_INT_PRIORITY"
      sgroup "VADC_HM1_USR_INT_PRIORITY (at 0x311b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC_HM1_USR_DATA_HOLD_CTL"
      sgroup "VADC_HM1_USR_DATA_HOLD_CTL (at 0x313f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80313f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x313f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD                                     = " "0 (FREE_RUNNING),1 (HOLD_DATA)"
    tree.end
    tree "VADC_HM1_USR_ADC_DIG_PARAM"
      sgroup "VADC_HM1_USR_ADC_DIG_PARAM (at 0x3142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_VAL                                  = " "0 (TIMER_CAL),1 (NEW_CAL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CAL_SEL                                  = " "0 (NO_CAL),1 (RATIO_CAL),2 (ABS_CAL),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DEC_RATIO_256),1 (DEC_RATIO_512),2 (DEC_RATIO_1024),3 (reserved)"
    tree.end
    tree "VADC_HM1_USR_FAST_AVG_CTL"
      sgroup "VADC_HM1_USR_FAST_AVG_CTL (at 0x3143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FAST_AVG_SAMPLES                         = " "0 (AVG_1_SAMPLE),1 (AVG_2_SAMPLES),2 (AVG_4_SAMPLES),3 (AVG_8_SAMPLES),4 (AVG_16_SAMPLES),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "VADC_HM1_USR_ADC_CH_SEL_CTL"
      sgroup "VADC_HM1_USR_ADC_CH_SEL_CTL (at 0x3144)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC_HM1_USR_DELAY_CTL"
      sgroup "VADC_HM1_USR_DELAY_CTL (at 0x3145)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC_HM1_USR_EN_CTL1"
      sgroup "VADC_HM1_USR_EN_CTL1 (at 0x3146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC_HM1_USR_CONV_REQ"
      sgroup "VADC_HM1_USR_CONV_REQ (at 0x3147)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (NO_OPERATION),1 (START_CONV_REQ)"
    tree.end
    tree "VADC_HM1_USR_VBAT_MIN_THR0"
      sgroup "VADC_HM1_USR_VBAT_MIN_THR0 (at 0x3148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_MIN_THR_7_0                         = "
    tree.end
    tree "VADC_HM1_USR_VBAT_MIN_THR1"
      sgroup "VADC_HM1_USR_VBAT_MIN_THR1 (at 0x3149)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_MIN_THR_15_8                        = "
    tree.end
    tree "VADC_HM1_USR_DATA0"
      sgroup "VADC_HM1_USR_DATA0 (at 0x3150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_HM1_USR_DATA1"
      sgroup "VADC_HM1_USR_DATA1 (at 0x3151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_HM1_USR_VBAT_MIN_DATA0"
      sgroup "VADC_HM1_USR_VBAT_MIN_DATA0 (at 0x3152)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_HM1_USR_VBAT_MIN_DATA1"
      sgroup "VADC_HM1_USR_VBAT_MIN_DATA1 (at 0x3153)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_HM1_USR_SEC_ACCESS"
      sgroup "VADC_HM1_USR_SEC_ACCESS (at 0x31d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC_HM1_USR_PERPH_RESET_CTL1"
      sgroup "VADC_HM1_USR_PERPH_RESET_CTL1 (at 0x31d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC_HM1_USR_PERPH_RESET_CTL2"
      sgroup "VADC_HM1_USR_PERPH_RESET_CTL2 (at 0x31d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM1_USR_PERPH_RESET_CTL3"
      sgroup "VADC_HM1_USR_PERPH_RESET_CTL3 (at 0x31da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC_HM1_USR_PERPH_RESET_CTL4"
      sgroup "VADC_HM1_USR_PERPH_RESET_CTL4 (at 0x31db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM1_USR_INT_TEST1"
      sgroup "VADC_HM1_USR_INT_TEST1 (at 0x31e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC_HM1_USR_INT_TEST_VAL"
      sgroup "VADC_HM1_USR_INT_TEST_VAL (at 0x31e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_TEST_VAL                    = " "0 (VBAT_MIN_TEST_FALSE),1 (VBAT_MIN_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC_HM1_USR_TEST1"
      sgroup "VADC_HM1_USR_TEST1 (at 0x31e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "VADC_HM2_MDM"
  tree "VADC_HM2_MDM"
    tree "VADC_HM2_MDM_REVISION1"
      sgroup "VADC_HM2_MDM_REVISION1 (at 0x3200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC_HM2_MDM_REVISION2"
      sgroup "VADC_HM2_MDM_REVISION2 (at 0x3201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC_HM2_MDM_REVISION3"
      sgroup "VADC_HM2_MDM_REVISION3 (at 0x3202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC_HM2_MDM_REVISION4"
      sgroup "VADC_HM2_MDM_REVISION4 (at 0x3203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC_HM2_MDM_PERPH_TYPE"
      sgroup "VADC_HM2_MDM_PERPH_TYPE (at 0x3204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC_HM2_MDM_PERPH_SUBTYPE"
      sgroup "VADC_HM2_MDM_PERPH_SUBTYPE (at 0x3205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC_HM2_MDM_STATUS1"
      sgroup "VADC_HM2_MDM_STATUS1 (at 0x3208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC_HM2_MDM_INT_RT_STS"
      sgroup "VADC_HM2_MDM_INT_RT_STS (at 0x3210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_THR_INT_RT_STS                  = " "0 (VBAT_MIN_THR_INT_FALSE),1 (VBAT_MIN_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_INT_SET_TYPE"
      sgroup "VADC_HM2_MDM_INT_SET_TYPE (at 0x3211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_THR_INT_TYPE                    = " "0 (VBAT_MIN_THR_LEVEL),1 (VBAT_MIN_THR_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC_HM2_MDM_INT_POLARITY_HIGH"
      sgroup "VADC_HM2_MDM_INT_POLARITY_HIGH (at 0x3212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_HIGH                        = " "0 (VBAT_MIN_INT_POL_HIGH_DISABLED),1 (VBAT_MIN_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC_HM2_MDM_INT_POLARITY_LOW"
      sgroup "VADC_HM2_MDM_INT_POLARITY_LOW (at 0x3213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_LOW                         = " "0 (VBAT_MIN_INT_POL_LOW_DISABLED),1 (VBAT_MIN_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC_HM2_MDM_INT_LATCHED_CLR"
      sgroup "VADC_HM2_MDM_INT_LATCHED_CLR (at 0x3214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC_HM2_MDM_INT_EN_SET"
      sgroup "VADC_HM2_MDM_INT_EN_SET (at 0x3215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_EN_SET                      = " "0 (VBAT_MIN_INT_DISABLED),1 (VBAT_MIN_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM2_MDM_INT_EN_CLR"
      sgroup "VADC_HM2_MDM_INT_EN_CLR (at 0x3216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_EN_CLR                      = " "0 (VBAT_MIN_INT_DISABLED),1 (VBAT_MIN_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM2_MDM_INT_LATCHED_STS"
      sgroup "VADC_HM2_MDM_INT_LATCHED_STS (at 0x3218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_LATCHED_STS                 = " "0 (VBAT_MIN_INT_LATCHED_FALSE),1 (VBAT_MIN_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_INT_PENDING_STS"
      sgroup "VADC_HM2_MDM_INT_PENDING_STS (at 0x3219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_PENDING_STS                 = " "0 (VBAT_MIN_INT_PENDING_FALSE),1 (VBAT_MIN_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_INT_MID_SEL"
      sgroup "VADC_HM2_MDM_INT_MID_SEL (at 0x321a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80321a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x321a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC_HM2_MDM_INT_PRIORITY"
      sgroup "VADC_HM2_MDM_INT_PRIORITY (at 0x321b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80321b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x321b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC_HM2_MDM_DATA_HOLD_CTL"
      sgroup "VADC_HM2_MDM_DATA_HOLD_CTL (at 0x323f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x80323f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x323f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD                                     = " "0 (FREE_RUNNING),1 (HOLD_DATA)"
    tree.end
    tree "VADC_HM2_MDM_ADC_DIG_PARAM"
      sgroup "VADC_HM2_MDM_ADC_DIG_PARAM (at 0x3242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_VAL                                  = " "0 (TIMER_CAL),1 (NEW_CAL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CAL_SEL                                  = " "0 (NO_CAL),1 (RATIO_CAL),2 (ABS_CAL),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DEC_RATIO_256),1 (DEC_RATIO_512),2 (DEC_RATIO_1024),3 (reserved)"
    tree.end
    tree "VADC_HM2_MDM_FAST_AVG_CTL"
      sgroup "VADC_HM2_MDM_FAST_AVG_CTL (at 0x3243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FAST_AVG_SAMPLES                         = " "0 (AVG_1_SAMPLE),1 (AVG_2_SAMPLES),2 (AVG_4_SAMPLES),3 (AVG_8_SAMPLES),4 (AVG_16_SAMPLES),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "VADC_HM2_MDM_ADC_CH_SEL_CTL"
      sgroup "VADC_HM2_MDM_ADC_CH_SEL_CTL (at 0x3244)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC_HM2_MDM_DELAY_CTL"
      sgroup "VADC_HM2_MDM_DELAY_CTL (at 0x3245)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC_HM2_MDM_EN_CTL1"
      sgroup "VADC_HM2_MDM_EN_CTL1 (at 0x3246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC_HM2_MDM_CONV_REQ"
      sgroup "VADC_HM2_MDM_CONV_REQ (at 0x3247)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (NO_OPERATION),1 (START_CONV_REQ)"
    tree.end
    tree "VADC_HM2_MDM_VBAT_MIN_THR0"
      sgroup "VADC_HM2_MDM_VBAT_MIN_THR0 (at 0x3248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_MIN_THR_7_0                         = "
    tree.end
    tree "VADC_HM2_MDM_VBAT_MIN_THR1"
      sgroup "VADC_HM2_MDM_VBAT_MIN_THR1 (at 0x3249)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VBAT_MIN_THR_15_8                        = "
    tree.end
    tree "VADC_HM2_MDM_DATA0"
      sgroup "VADC_HM2_MDM_DATA0 (at 0x3250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_HM2_MDM_DATA1"
      sgroup "VADC_HM2_MDM_DATA1 (at 0x3251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_HM2_MDM_VBAT_MIN_DATA0"
      sgroup "VADC_HM2_MDM_VBAT_MIN_DATA0 (at 0x3252)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_HM2_MDM_VBAT_MIN_DATA1"
      sgroup "VADC_HM2_MDM_VBAT_MIN_DATA1 (at 0x3253)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_HM2_MDM_SEC_ACCESS"
      sgroup "VADC_HM2_MDM_SEC_ACCESS (at 0x32d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC_HM2_MDM_PERPH_RESET_CTL1"
      sgroup "VADC_HM2_MDM_PERPH_RESET_CTL1 (at 0x32d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC_HM2_MDM_PERPH_RESET_CTL2"
      sgroup "VADC_HM2_MDM_PERPH_RESET_CTL2 (at 0x32d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_PERPH_RESET_CTL3"
      sgroup "VADC_HM2_MDM_PERPH_RESET_CTL3 (at 0x32da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_PERPH_RESET_CTL4"
      sgroup "VADC_HM2_MDM_PERPH_RESET_CTL4 (at 0x32db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_INT_TEST1"
      sgroup "VADC_HM2_MDM_INT_TEST1 (at 0x32e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_INT_TEST_VAL"
      sgroup "VADC_HM2_MDM_INT_TEST_VAL (at 0x32e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VBAT_MIN_INT_TEST_VAL                    = " "0 (VBAT_MIN_TEST_FALSE),1 (VBAT_MIN_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC_HM2_MDM_TEST1"
      sgroup "VADC_HM2_MDM_TEST1 (at 0x32e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        set &access:&cmd_addr %l 0x8032e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x32e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "VADC_HM3_PBS"
  tree "VADC_HM3_PBS"
    tree "VADC_HM3_PBS_REVISION1"
      sgroup "VADC_HM3_PBS_REVISION1 (at 0x3600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC_HM3_PBS_REVISION2"
      sgroup "VADC_HM3_PBS_REVISION2 (at 0x3601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC_HM3_PBS_REVISION3"
      sgroup "VADC_HM3_PBS_REVISION3 (at 0x3602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC_HM3_PBS_REVISION4"
      sgroup "VADC_HM3_PBS_REVISION4 (at 0x3603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC_HM3_PBS_PERPH_TYPE"
      sgroup "VADC_HM3_PBS_PERPH_TYPE (at 0x3604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC_HM3_PBS_PERPH_SUBTYPE"
      sgroup "VADC_HM3_PBS_PERPH_SUBTYPE (at 0x3605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC_HM3_PBS_STATUS1"
      sgroup "VADC_HM3_PBS_STATUS1 (at 0x3608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC_HM3_PBS_INT_RT_STS"
      sgroup "VADC_HM3_PBS_INT_RT_STS (at 0x3610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_INT_SET_TYPE"
      sgroup "VADC_HM3_PBS_INT_SET_TYPE (at 0x3611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC_HM3_PBS_INT_POLARITY_HIGH"
      sgroup "VADC_HM3_PBS_INT_POLARITY_HIGH (at 0x3612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC_HM3_PBS_INT_POLARITY_LOW"
      sgroup "VADC_HM3_PBS_INT_POLARITY_LOW (at 0x3613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC_HM3_PBS_INT_LATCHED_CLR"
      sgroup "VADC_HM3_PBS_INT_LATCHED_CLR (at 0x3614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC_HM3_PBS_INT_EN_SET"
      sgroup "VADC_HM3_PBS_INT_EN_SET (at 0x3615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM3_PBS_INT_EN_CLR"
      sgroup "VADC_HM3_PBS_INT_EN_CLR (at 0x3616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM3_PBS_INT_LATCHED_STS"
      sgroup "VADC_HM3_PBS_INT_LATCHED_STS (at 0x3618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_INT_PENDING_STS"
      sgroup "VADC_HM3_PBS_INT_PENDING_STS (at 0x3619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_INT_MID_SEL"
      sgroup "VADC_HM3_PBS_INT_MID_SEL (at 0x361a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80361a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x361a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC_HM3_PBS_INT_PRIORITY"
      sgroup "VADC_HM3_PBS_INT_PRIORITY (at 0x361b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80361b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x361b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC_HM3_PBS_ADC_DIG_PARAM"
      sgroup "VADC_HM3_PBS_ADC_DIG_PARAM (at 0x3642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CAL_VAL                                  = " "0 (TIMER_CAL),1 (NEW_CAL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CAL_SEL                                  = " "0 (NO_CAL),1 (RATIO_CAL),2 (ABS_CAL),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DEC_RATIO_256),1 (DEC_RATIO_512),2 (DEC_RATIO_1024),3 (reserved)"
    tree.end
    tree "VADC_HM3_PBS_FAST_AVG_CTL"
      sgroup "VADC_HM3_PBS_FAST_AVG_CTL (at 0x3643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FAST_AVG_SAMPLES                         = " "0 (AVG_1_SAMPLE),1 (AVG_2_SAMPLES),2 (AVG_4_SAMPLES),3 (AVG_8_SAMPLES),4 (AVG_16_SAMPLES),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "VADC_HM3_PBS_ADC_CH_SEL_CTL"
      sgroup "VADC_HM3_PBS_ADC_CH_SEL_CTL (at 0x3644)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC_HM3_PBS_DELAY_CTL"
      sgroup "VADC_HM3_PBS_DELAY_CTL (at 0x3645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC_HM3_PBS_EN_CTL1"
      sgroup "VADC_HM3_PBS_EN_CTL1 (at 0x3646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC_HM3_PBS_CONV_REQ"
      sgroup "VADC_HM3_PBS_CONV_REQ (at 0x3647)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (NO_OPERATION),1 (START_CONV_REQ)"
    tree.end
    tree "VADC_HM3_PBS_DATA0"
      sgroup "VADC_HM3_PBS_DATA0 (at 0x3650)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_HM3_PBS_DATA1"
      sgroup "VADC_HM3_PBS_DATA1 (at 0x3651)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_HM3_PBS_SEC_ACCESS"
      sgroup "VADC_HM3_PBS_SEC_ACCESS (at 0x36d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC_HM3_PBS_PERPH_RESET_CTL1"
      sgroup "VADC_HM3_PBS_PERPH_RESET_CTL1 (at 0x36d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC_HM3_PBS_PERPH_RESET_CTL2"
      sgroup "VADC_HM3_PBS_PERPH_RESET_CTL2 (at 0x36d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_PERPH_RESET_CTL3"
      sgroup "VADC_HM3_PBS_PERPH_RESET_CTL3 (at 0x36da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_PERPH_RESET_CTL4"
      sgroup "VADC_HM3_PBS_PERPH_RESET_CTL4 (at 0x36db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_INT_TEST1"
      sgroup "VADC_HM3_PBS_INT_TEST1 (at 0x36e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_INT_TEST_VAL"
      sgroup "VADC_HM3_PBS_INT_TEST_VAL (at 0x36e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC_HM3_PBS_TEST1"
      sgroup "VADC_HM3_PBS_TEST1 (at 0x36e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "VADC_HM4_CAL"
  tree "VADC_HM4_CAL"
    tree "VADC_HM4_CAL_REVISION1"
      sgroup "VADC_HM4_CAL_REVISION1 (at 0x3700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC_HM4_CAL_REVISION2"
      sgroup "VADC_HM4_CAL_REVISION2 (at 0x3701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC_HM4_CAL_REVISION3"
      sgroup "VADC_HM4_CAL_REVISION3 (at 0x3702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC_HM4_CAL_REVISION4"
      sgroup "VADC_HM4_CAL_REVISION4 (at 0x3703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC_HM4_CAL_PERPH_TYPE"
      sgroup "VADC_HM4_CAL_PERPH_TYPE (at 0x3704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC_HM4_CAL_PERPH_SUBTYPE"
      sgroup "VADC_HM4_CAL_PERPH_SUBTYPE (at 0x3705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC_HM4_CAL_STATUS1"
      sgroup "VADC_HM4_CAL_STATUS1 (at 0x3708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC_HM4_CAL_INT_RT_STS"
      sgroup "VADC_HM4_CAL_INT_RT_STS (at 0x3710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_INT_SET_TYPE"
      sgroup "VADC_HM4_CAL_INT_SET_TYPE (at 0x3711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC_HM4_CAL_INT_POLARITY_HIGH"
      sgroup "VADC_HM4_CAL_INT_POLARITY_HIGH (at 0x3712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC_HM4_CAL_INT_POLARITY_LOW"
      sgroup "VADC_HM4_CAL_INT_POLARITY_LOW (at 0x3713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC_HM4_CAL_INT_LATCHED_CLR"
      sgroup "VADC_HM4_CAL_INT_LATCHED_CLR (at 0x3714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC_HM4_CAL_INT_EN_SET"
      sgroup "VADC_HM4_CAL_INT_EN_SET (at 0x3715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM4_CAL_INT_EN_CLR"
      sgroup "VADC_HM4_CAL_INT_EN_CLR (at 0x3716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_HM4_CAL_INT_LATCHED_STS"
      sgroup "VADC_HM4_CAL_INT_LATCHED_STS (at 0x3718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_INT_PENDING_STS"
      sgroup "VADC_HM4_CAL_INT_PENDING_STS (at 0x3719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_INT_MID_SEL"
      sgroup "VADC_HM4_CAL_INT_MID_SEL (at 0x371a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80371a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x371a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC_HM4_CAL_INT_PRIORITY"
      sgroup "VADC_HM4_CAL_INT_PRIORITY (at 0x371b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80371b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x371b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC_HM4_CAL_ADC_DIG_PARAM"
      sgroup "VADC_HM4_CAL_ADC_DIG_PARAM (at 0x3742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DEC_RATIO_256),1 (DEC_RATIO_512),2 (DEC_RATIO_1024),3 (reserved)"
    tree.end
    tree "VADC_HM4_CAL_FAST_AVG_CTL"
      sgroup "VADC_HM4_CAL_FAST_AVG_CTL (at 0x3743)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FAST_AVG_SAMPLES                         = " "0 (AVG_1_SAMPLE),1 (AVG_2_SAMPLES),2 (AVG_4_SAMPLES),3 (AVG_8_SAMPLES),4 (AVG_16_SAMPLES),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "VADC_HM4_CAL_DELAY_CTL"
      sgroup "VADC_HM4_CAL_DELAY_CTL (at 0x3745)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CAL_MEAS_INTERVAL_TIME                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC_HM4_CAL_EN_CTL1"
      sgroup "VADC_HM4_CAL_EN_CTL1 (at 0x3746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC_HM4_CAL_CONV_REQ"
      sgroup "VADC_HM4_CAL_CONV_REQ (at 0x3747)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (NO_OPERATION),1 (START_CONV_REQ)"
    tree.end
    tree "VADC_HM4_CAL_GND_REF_D0"
      sgroup "VADC_HM4_CAL_GND_REF_D0 (at 0x3750)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GND_REF_DATA_7_0                         = "
    tree.end
    tree "VADC_HM4_CAL_GND_REF_D1"
      sgroup "VADC_HM4_CAL_GND_REF_D1 (at 0x3751)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GND_REF_DATA_15_8                        = "
    tree.end
    tree "VADC_HM4_CAL_VREF_VADC_D0"
      sgroup "VADC_HM4_CAL_VREF_VADC_D0 (at 0x3752)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VREF_VADC_DATA_7_0                       = "
    tree.end
    tree "VADC_HM4_CAL_VREF_VADC_D1"
      sgroup "VADC_HM4_CAL_VREF_VADC_D1 (at 0x3753)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VREF_VADC_DATA_15_8                      = "
    tree.end
    tree "VADC_HM4_CAL_REF_1P25_D0"
      sgroup "VADC_HM4_CAL_REF_1P25_D0 (at 0x3754)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   REF_1P25_DATA_7_0                        = "
    tree.end
    tree "VADC_HM4_CAL_REF_1P25_D1"
      sgroup "VADC_HM4_CAL_REF_1P25_D1 (at 0x3755)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   REF_1P25_DATA_15_8                       = "
    tree.end
    tree "VADC_HM4_CAL_SEC_ACCESS"
      sgroup "VADC_HM4_CAL_SEC_ACCESS (at 0x37d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC_HM4_CAL_PERPH_RESET_CTL1"
      sgroup "VADC_HM4_CAL_PERPH_RESET_CTL1 (at 0x37d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC_HM4_CAL_PERPH_RESET_CTL2"
      sgroup "VADC_HM4_CAL_PERPH_RESET_CTL2 (at 0x37d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_PERPH_RESET_CTL3"
      sgroup "VADC_HM4_CAL_PERPH_RESET_CTL3 (at 0x37da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_PERPH_RESET_CTL4"
      sgroup "VADC_HM4_CAL_PERPH_RESET_CTL4 (at 0x37db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_INT_TEST1"
      sgroup "VADC_HM4_CAL_INT_TEST1 (at 0x37e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_INT_TEST_VAL"
      sgroup "VADC_HM4_CAL_INT_TEST_VAL (at 0x37e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC_HM4_CAL_TEST1"
      sgroup "VADC_HM4_CAL_TEST1 (at 0x37e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "VADC_HM4_CAL_TEST2_CAL_CH_SEL"
      sgroup "VADC_HM4_CAL_TEST2_CAL_CH_SEL (at 0x37e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   REF_1P25_CH_EN                           = " "0 (REF_1P25_CAL_DIS),1 (REF_1P25_CAL_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VREF_VADC_CH_EN                          = " "0 (VREF_VADC_CAL_DIS),1 (VREF_VADC_CAL_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GND_REF_CH_EN                            = " "0 (GND_REF_CAL_DIS),1 (GND_REF_CAL_EN)"
    tree.end
  tree.end
tree.end
tree "VADC_HM9_BTM_2"
  tree "VADC_HM9_BTM_2"
    tree "VADC_HM9_BTM_2_REVISION1"
      sgroup "VADC_HM9_BTM_2_REVISION1 (at 0x3800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC_HM9_BTM_2_REVISION2"
      sgroup "VADC_HM9_BTM_2_REVISION2 (at 0x3801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC_HM9_BTM_2_REVISION3"
      sgroup "VADC_HM9_BTM_2_REVISION3 (at 0x3802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC_HM9_BTM_2_REVISION4"
      sgroup "VADC_HM9_BTM_2_REVISION4 (at 0x3803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC_HM9_BTM_2_PERPH_TYPE"
      sgroup "VADC_HM9_BTM_2_PERPH_TYPE (at 0x3804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC_HM9_BTM_2_PERPH_SUBTYPE"
      sgroup "VADC_HM9_BTM_2_PERPH_SUBTYPE (at 0x3805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC_HM9_BTM_2_STATUS1"
      sgroup "VADC_HM9_BTM_2_STATUS1 (at 0x3808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC_HM9_BTM_2_STATUS_LOW"
      sgroup "VADC_HM9_BTM_2_STATUS_LOW (at 0x380a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80380a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x380a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_LOW                                   = " "0 (M1_LOW_FALSE),1 (M1_LOW_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW                                   = " "0 (M0_LOW_FALSE),1 (M0_LOW_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_STATUS_HIGH"
      sgroup "VADC_HM9_BTM_2_STATUS_HIGH (at 0x380b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80380b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x380b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH                                  = " "0 (M1_HIGH_FALSE),1 (M1_HIGH_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_HIGH                                  = " "0 (M0_HIGH_FALSE),1 (M0_HIGH_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_RT_STS"
      sgroup "VADC_HM9_BTM_2_INT_RT_STS (at 0x3810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_RT_STS                      = " "0 (VCOMP_HI_INT_FALSE),1 (VCOMP_HI_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_RT_STS               = " "0 (VCOMP_FAST_LOW2_INT_FALSE),1 (VCOMP_FAST_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_RT_STS                    = " "0 (VCOMP_LOW2_INT_FALSE),1 (VCOMP_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_RT_STS               = " "0 (VCOMP_FAST_LOW1_INT_FALSE),1 (VCOMP_FAST_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_RT_STS                    = " "0 (VCOMP_LOW1_INT_FALSE),1 (VCOMP_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_RT_STS                           = " "0 (THR_INT_FALSE),1 (THR_INT_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_SET_TYPE"
      sgroup "VADC_HM9_BTM_2_INT_SET_TYPE (at 0x3811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_SET_TYPE                    = " "0 (VCOMP_HI_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_HI_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_SET_TYPE             = " "0 (VCOMP_FAST_LOW2_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_FAST_LOW2_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_SET_TYPE                  = " "0 (VCOMP_LOW2_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_LOW2_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_SET_TYPE             = " "0 (VCOMP_FAST_LOW1_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_FAST_LOW1_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_SET_TYPE                  = " "0 (VCOMP_LOW1_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_LOW1_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_SET_TYPE                         = " "0 (THR_INT_POL_HIGH_DISABLED),1 (THR_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_POLARITY_HIGH"
      sgroup "VADC_HM9_BTM_2_INT_POLARITY_HIGH (at 0x3812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_HIGH                        = " "0 (VCOMP_HI_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_HI_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_HIGH                 = " "0 (VCOMP_FAST_LOW2_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_FAST_LOW2_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_HIGH                      = " "0 (VCOMP_LOW2_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_LOW2_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_HIGH                 = " "0 (VCOMP_FAST_LOW1_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_FAST_LOW1_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_HIGH                      = " "0 (VCOMP_LOW1_THR_INT_POL_HIGH_DISABLED),1 (VCOMP_LOW1_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_HIGH                             = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_POLARITY_LOW"
      sgroup "VADC_HM9_BTM_2_INT_POLARITY_LOW (at 0x3813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_LOW                         = " "0 (VCOMP_HI_THR_INT_POL_DISABLED),1 (VCOMP_HI_THR_INT_POL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_LOW                  = " "0 (VCOMP_FAST_LOW2_THR_INT_POL_DISABLED),1 (VCOMP_FAST_LOW2_THR_INT_POL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_LOW                       = " "0 (VCOMP_LOW2_THR_INT_POL_DISABLED),1 (VCOMP_LOW2_THR_INT_POL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_LOW                  = " "0 (VCOMP_FAST_LOW1_THR_INT_POL_DISABLED),1 (VCOMP_FAST_LOW1_THR_INT_POL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_LOW                       = " "0 (VCOMP_LOW1_THR_INT_POL_DISABLED),1 (VCOMP_LOW1_THR_INT_POL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_LOW                              = " "0 (THR_INT_POL_DISABLED),1 (THR_INT_POL_ENABLED)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_LATCHED_CLR"
      sgroup "VADC_HM9_BTM_2_INT_LATCHED_CLR (at 0x3814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_LATCHED_CLR                 = " "0 (VCOMP_HI_INT_FALSE),1 (VCOMP_HI_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_LATCHED_CLR          = " "0 (VCOMP_FAST_LOW2_INT_FALSE),1 (VCOMP_FAST_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_LATCHED_CLR               = " "0 (VCOMP_LOW2_INT_FALSE),1 (VCOMP_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_LATCHED_CLR          = " "0 (VCOMP_FAST_LOW1_INT_FALSE),1 (VCOMP_FAST_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_LATCHED_CLR               = " "0 (VCOMP_LOW1_INT_FALSE),1 (VCOMP_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC_HM9_BTM_2_INT_EN_SET"
      sgroup "VADC_HM9_BTM_2_INT_EN_SET (at 0x3815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_EN_SET                      = " "0 (VCOMP_HI_INT_FALSE),1 (VCOMP_HI_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_EN_SET               = " "0 (VCOMP_FAST_LOW2_INT_FALSE),1 (VCOMP_FAST_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_EN_SET                    = " "0 (VCOMP_LOW2_INT_FALSE),1 (VCOMP_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_EN_SET               = " "0 (VCOMP_FAST_LOW1_INT_FALSE),1 (VCOMP_FAST_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_EN_SET                    = " "0 (VCOMP_LOW1_INT_FALSE),1 (VCOMP_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_EN_SET                           = " "0 (THR_INT_DISABLED),1 (THR_INT_ENBLED)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_EN_CLR"
      sgroup "VADC_HM9_BTM_2_INT_EN_CLR (at 0x3816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_EN_CLR                      = " "0 (VCOMP_HI_INT_FALSE),1 (VCOMP_HI_INT_TRUE)"
      textline ""
