      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_EN_CLR               = " "0 (VCOMP_FAST_LOW2_INT_FALSE),1 (VCOMP_FAST_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_EN_CLR                    = " "0 (VCOMP_LOW2_INT_FALSE),1 (VCOMP_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_EN_CLR               = " "0 (VCOMP_FAST_LOW1_INT_FALSE),1 (VCOMP_FAST_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_EN_CLR                    = " "0 (VCOMP_LOW1_INT_FALSE),1 (VCOMP_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_EN_CLR                           = " "0 (THR_INT_DISABLED),1 (THR_INT_ENBLED)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_LATCHED_STS"
      sgroup "VADC_HM9_BTM_2_INT_LATCHED_STS (at 0x3818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_LATCHED_STS                 = " "0 (VCOMP_HI_INT_FALSE),1 (VCOMP_HI_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_LATCHED_STS          = " "0 (VCOMP_FAST_LOW2_INT_FALSE),1 (VCOMP_FAST_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_LATCHED_STS               = " "0 (VCOMP_LOW2_INT_FALSE),1 (VCOMP_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_LATCHED_STS          = " "0 (VCOMP_FAST_LOW1_INT_FALSE),1 (VCOMP_FAST_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_LATCHED_STS               = " "0 (VCOMP_LOW1_INT_FALSE),1 (VCOMP_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_LATCHED_STS                      = " "0 (THR_INT_LATCHED_FALSE),1 (THR_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_PENDING_STS"
      sgroup "VADC_HM9_BTM_2_INT_PENDING_STS (at 0x3819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_LATCHED_STS                 = " "0 (VCOMP_HI_INT_FALSE),1 (VCOMP_HI_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_LATCHED_STS          = " "0 (VCOMP_FAST_LOW2_INT_FALSE),1 (VCOMP_FAST_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_LATCHED_STS               = " "0 (VCOMP_LOW2_INT_FALSE),1 (VCOMP_LOW2_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_LATCHED_STS          = " "0 (VCOMP_FAST_LOW1_INT_FALSE),1 (VCOMP_FAST_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_LATCHED_STS               = " "0 (VCOMP_LOW1_INT_FALSE),1 (VCOMP_LOW1_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_PENDING_STS                      = " "0 (THR_INT_PENDING_FALSE),1 (THR_INT_PENDING_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_MID_SEL"
      sgroup "VADC_HM9_BTM_2_INT_MID_SEL (at 0x381a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80381a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x381a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC_HM9_BTM_2_INT_PRIORITY"
      sgroup "VADC_HM9_BTM_2_INT_PRIORITY (at 0x381b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80381b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x381b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC_HM9_BTM_2_DATA_HOLD_CTL"
      sgroup "VADC_HM9_BTM_2_DATA_HOLD_CTL (at 0x383f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80383f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x383f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD                                     = " "0 (FREE_RUNNING),1 (HOLD_DATA)"
    tree.end
    tree "VADC_HM9_BTM_2_MODE_CTL"
      sgroup "VADC_HM9_BTM_2_MODE_CTL (at 0x3840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_HI_EN                              = " "0 (VCOMP_HI_EN_FALSE),1 (VCOMP_HI_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_EN                            = " "0 (VCOMP_LOW2_EN_FALSE),1 (VCOMP_LOW2_EN_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_LOW1_EN                            = " "0 (VCOMP_LOW1_EN_FALSE),1 (VCOMP_LOW1_EN_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_ADC_DIG_PARAM"
      sgroup "VADC_HM9_BTM_2_ADC_DIG_PARAM (at 0x3842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DEC_RATIO_256),1 (DEC_RATIO_512),2 (DEC_RATIO_1024),3 (reserved)"
    tree.end
    tree "VADC_HM9_BTM_2_FAST_AVG_CTL"
      sgroup "VADC_HM9_BTM_2_FAST_AVG_CTL (at 0x3843)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   FAST_AVG_SAMPLES                         = " "0 (AVG_1_SAMPLE),1 (AVG_2_SAMPLES),2 (AVG_4_SAMPLES),3 (AVG_8_SAMPLES),4 (AVG_16_SAMPLES),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "VADC_HM9_BTM_2_EN_CTL1"
      sgroup "VADC_HM9_BTM_2_EN_CTL1 (at 0x3846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC_HM9_BTM_2_CONV_REQ"
      sgroup "VADC_HM9_BTM_2_CONV_REQ (at 0x3847)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (NO_OPERATION),1 (START_CONV_REQ)"
    tree.end
    tree "VADC_HM9_BTM_2_VCOMP_HI_THR"
      sgroup "VADC_HM9_BTM_2_VCOMP_HI_THR (at 0x3848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VCOMP_HI_THR                             = "
    tree.end
    tree "VADC_HM9_BTM_2_VCOMP_LOW2_THR"
      sgroup "VADC_HM9_BTM_2_VCOMP_LOW2_THR (at 0x3849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VCOMP_LOW2_THR                           = "
    tree.end
    tree "VADC_HM9_BTM_2_VCOMP_LOW1_THR"
      sgroup "VADC_HM9_BTM_2_VCOMP_LOW1_THR (at 0x384a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80384a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x384a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VCOMP_LOW1_THR                           = "
    tree.end
    tree "VADC_HM9_BTM_2_VCOMP_HI_DEBOUNCE"
      sgroup "VADC_HM9_BTM_2_VCOMP_HI_DEBOUNCE (at 0x384b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80384b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x384b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VCOMP_HI_DEBOUNCE                        = " "0 (DEB_0),1 (DEB_1US),2 (DEB_2US),3 (DEB_4US),4 (DEB_8US),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "VADC_HM9_BTM_2_VCOMP_LOW2_DEBOUNCE"
      sgroup "VADC_HM9_BTM_2_VCOMP_LOW2_DEBOUNCE (at 0x384c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80384c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x384c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VCOMP_LOW2_DEBOUNCE                      = "
    tree.end
    tree "VADC_HM9_BTM_2_VCOMP_LOW1_DEBOUNCE"
      sgroup "VADC_HM9_BTM_2_VCOMP_LOW1_DEBOUNCE (at 0x384d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80384d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x384d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VCOMP_LOW1_DEBOUNCE                      = "
    tree.end
    tree "VADC_HM9_BTM_2_MEAS_INTERVAL_CTL"
      sgroup "VADC_HM9_BTM_2_MEAS_INTERVAL_CTL (at 0x3850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME1                      = "
    tree.end
    tree "VADC_HM9_BTM_2_MEAS_INTERVAL_CTL2"
      sgroup "VADC_HM9_BTM_2_MEAS_INTERVAL_CTL2 (at 0x3851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MEAS_INTERVAL_TIME2                      = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME3                      = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_ADC_CH_SEL_CTL"
      sgroup "VADC_HM9_BTM_2_M0_ADC_CH_SEL_CTL (at 0x3860)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_LOW_THR0"
      sgroup "VADC_HM9_BTM_2_M0_LOW_THR0 (at 0x3861)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_LOW_THR1"
      sgroup "VADC_HM9_BTM_2_M0_LOW_THR1 (at 0x3862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_HIGH_THR0"
      sgroup "VADC_HM9_BTM_2_M0_HIGH_THR0 (at 0x3863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_HIGH_THR1"
      sgroup "VADC_HM9_BTM_2_M0_HIGH_THR1 (at 0x3864)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_MEAS_INTERVAL_CTL"
      sgroup "VADC_HM9_BTM_2_M0_MEAS_INTERVAL_CTL (at 0x3865)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M0_MEAS_INTERVAL_TIME                    = " "0 (M0_USING_TIMER1),1 (M0_USING_TIMER2),2 (M0_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC_HM9_BTM_2_M0_CTL"
      sgroup "VADC_HM9_BTM_2_M0_CTL (at 0x3866)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M0_CAL_VAL                               = " "0 (TIMER_CAL),1 (NEW_CAL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   M0_CAL_SEL                               = " "0 (NO_CAL),1 (RATIO_CAL),2 (ABS_CAL),3 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   M0_HW_SETTLE_DELAY                       = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_EN"
      sgroup "VADC_HM9_BTM_2_M0_EN (at 0x3867)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M0_MEAS_EN                               = " "0 (M0_MEAS_DISABLE),1 (M0_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M0_HIGH_THR_INT_EN                       = " "0 (M0_HIGH_THR_INT_DISABLED),1 (M0_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M0_LOW_THR_INT_EN                        = " "0 (M0_LOW_THR_INT_DISABLED),1 (M0_LOW_THR_INT_ENABLED)"
    tree.end
    tree "VADC_HM9_BTM_2_M1_ADC_CH_SEL_CTL"
      sgroup "VADC_HM9_BTM_2_M1_ADC_CH_SEL_CTL (at 0x3868)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_LOW_THR0"
      sgroup "VADC_HM9_BTM_2_M1_LOW_THR0 (at 0x3869)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_LOW_THR1"
      sgroup "VADC_HM9_BTM_2_M1_LOW_THR1 (at 0x386a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80386a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x386a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_HIGH_THR0"
      sgroup "VADC_HM9_BTM_2_M1_HIGH_THR0 (at 0x386b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80386b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x386b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_HIGH_THR1"
      sgroup "VADC_HM9_BTM_2_M1_HIGH_THR1 (at 0x386c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80386c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x386c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_MEAS_INTERVAL_CTL"
      sgroup "VADC_HM9_BTM_2_M1_MEAS_INTERVAL_CTL (at 0x386d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80386d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x386d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   M1_MEAS_INTERVAL_TIME                    = " "0 (M1_USING_TIMER1),1 (M1_USING_TIMER2),2 (M1_USING_TIMER3),3 (reserved)"
    tree.end
    tree "VADC_HM9_BTM_2_M1_CTL"
      sgroup "VADC_HM9_BTM_2_M1_CTL (at 0x386e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80386e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x386e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   M1_CAL_VAL                               = " "0 (TIMER_CAL),1 (NEW_CAL)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   M1_CAL_SEL                               = " "0 (NO_CAL),1 (RATIO_CAL),2 (ABS_CAL),3 (reserved)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   M1_HW_SETTLE_DELAY                       = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_EN"
      sgroup "VADC_HM9_BTM_2_M1_EN (at 0x386f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x80386f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x386f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   M1_MEAS_EN                               = " "0 (M1_MEAS_DISABLE),1 (M1_MEAS_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   M1_HIGH_THR_INT_EN                       = " "0 (M1_HIGH_THR_INT_DISABLED),1 (M1_HIGH_THR_INT_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   M1_LOW_THR_INT_EN                        = " "0 (M1_LOW_THR_INT_DISABLED),1 (M1_LOW_THR_INT_ENABLED)"
    tree.end
    tree "VADC_HM9_BTM_2_M0_DATA0"
      sgroup "VADC_HM9_BTM_2_M0_DATA0 (at 0x38a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_HM9_BTM_2_M0_DATA1"
      sgroup "VADC_HM9_BTM_2_M0_DATA1 (at 0x38a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_DATA0"
      sgroup "VADC_HM9_BTM_2_M1_DATA0 (at 0x38a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_HM9_BTM_2_M1_DATA1"
      sgroup "VADC_HM9_BTM_2_M1_DATA1 (at 0x38a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_HM9_BTM_2_SEC_ACCESS"
      sgroup "VADC_HM9_BTM_2_SEC_ACCESS (at 0x38d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC_HM9_BTM_2_PERPH_RESET_CTL1"
      sgroup "VADC_HM9_BTM_2_PERPH_RESET_CTL1 (at 0x38d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC_HM9_BTM_2_PERPH_RESET_CTL2"
      sgroup "VADC_HM9_BTM_2_PERPH_RESET_CTL2 (at 0x38d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_PERPH_RESET_CTL3"
      sgroup "VADC_HM9_BTM_2_PERPH_RESET_CTL3 (at 0x38da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_PERPH_RESET_CTL4"
      sgroup "VADC_HM9_BTM_2_PERPH_RESET_CTL4 (at 0x38db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_TEST1"
      sgroup "VADC_HM9_BTM_2_INT_TEST1 (at 0x38e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_INT_TEST_VAL"
      sgroup "VADC_HM9_BTM_2_INT_TEST_VAL (at 0x38e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VCOMP_HI_INT_TEST_VAL                    = " "0 (VCOMP_HI_TEST_FALSE),1 (VCOMP_HI_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCOMP_FAST_LOW2_INT_TEST_VAL             = " "0 (VCOMP_FAST_LOW2_TEST_FALSE),1 (VCOMP_FAST_LOW2_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCOMP_LOW2_INT_TEST_VAL                  = " "0 (VCOMP_LOW2_TEST_FALSE),1 (VCOMP_LOW2_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VCOMP_FAST_LOW1_INT_TEST_VAL             = " "0 (VCOMP_FAST_LOW1_TEST_FALSE),1 (VCOMP_FAST_LOW1_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCOMP_LOW1_INT_TEST_VAL                  = " "0 (VCOMP_LOW1_TEST_FALSE),1 (VCOMP_LOW1_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THR_INT_TEST_VAL                         = " "0 (THR_TEST_FALSE),1 (THR_TEST_TRUE)"
    tree.end
    tree "VADC_HM9_BTM_2_TEST1"
      sgroup "VADC_HM9_BTM_2_TEST1 (at 0x38e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        set &access:&cmd_addr %l 0x8038e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x38e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM_1),1 (REQUEST_FSM_2),2 (reserved),3 (REQUEST_FSM_3)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "VBUS_DET"
  tree "VBUS_DET"
    tree "VBUS_DET_REVISION1"
      sgroup "VBUS_DET_REVISION1 (at 0xd00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VBUS_DET_REVISION2"
      sgroup "VBUS_DET_REVISION2 (at 0xd01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VBUS_DET_REVISION3"
      sgroup "VBUS_DET_REVISION3 (at 0xd02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VBUS_DET_REVISION4"
      sgroup "VBUS_DET_REVISION4 (at 0xd03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VBUS_DET_PERPH_TYPE"
      sgroup "VBUS_DET_PERPH_TYPE (at 0xd04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VBUS_DET_PERPH_SUBTYPE"
      sgroup "VBUS_DET_PERPH_SUBTYPE (at 0xd05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VBUS_DET_STATUS1"
      sgroup "VBUS_DET_STATUS1 (at 0xd08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VBUS_DET                                 = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_RT_STS"
      sgroup "VBUS_DET_INT_RT_STS (at 0xd10)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_STS                             = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_SET_TYPE"
      sgroup "VBUS_DET_INT_SET_TYPE (at 0xd11)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_TYPE                            = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_POLARITY_HIGH"
      sgroup "VBUS_DET_INT_POLARITY_HIGH (at 0xd12)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_HIGH                            = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_POLARITY_LOW"
      sgroup "VBUS_DET_INT_POLARITY_LOW (at 0xd13)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_LOW                             = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_LATCHED_CLR"
      sgroup "VBUS_DET_INT_LATCHED_CLR (at 0xd14)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_EN_SET"
      sgroup "VBUS_DET_INT_EN_SET (at 0xd15)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_EN_SET                          = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_EN_CLR"
      sgroup "VBUS_DET_INT_EN_CLR (at 0xd16)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_EN_CLR                          = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_LATCHED_STS"
      sgroup "VBUS_DET_INT_LATCHED_STS (at 0xd18)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_PENDING_STS"
      sgroup "VBUS_DET_INT_PENDING_STS (at 0xd19)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_PENDING_STS                     = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_MID_SEL"
      sgroup "VBUS_DET_INT_MID_SEL (at 0xd1a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VBUS_DET_INT_PRIORITY"
      sgroup "VBUS_DET_INT_PRIORITY (at 0xd1b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "VBUS_DET_SEC_ACCESS"
      sgroup "VBUS_DET_SEC_ACCESS (at 0xdd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VBUS_DET_PERPH_RESET_CTL2"
      sgroup "VBUS_DET_PERPH_RESET_CTL2 (at 0xdd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VBUS_DET_PERPH_RESET_CTL3"
      sgroup "VBUS_DET_PERPH_RESET_CTL3 (at 0xdda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xdda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VBUS_DET_PERPH_RESET_CTL4"
      sgroup "VBUS_DET_PERPH_RESET_CTL4 (at 0xddb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VBUS_DET_INT_TEST1"
      sgroup "VBUS_DET_INT_TEST1 (at 0xde0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "VBUS_DET_INT_TEST_VAL"
      sgroup "VBUS_DET_INT_TEST_VAL (at 0xde1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        set &access:&cmd_addr %l 0x800de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xd00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xde10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBUS_DET_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
  tree.end
tree.end
tree "VDDGEN"
  tree "VDDGEN"
    tree "VDDGEN_REVISION1"
      sgroup "VDDGEN_REVISION1 (at 0x3c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VDDGEN_REVISION2"
      sgroup "VDDGEN_REVISION2 (at 0x3c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VDDGEN_REVISION3"
      sgroup "VDDGEN_REVISION3 (at 0x3c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VDDGEN_REVISION4"
      sgroup "VDDGEN_REVISION4 (at 0x3c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VDDGEN_PERPH_TYPE"
      sgroup "VDDGEN_PERPH_TYPE (at 0x3c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VDDGEN_PERPH_SUBTYPE"
      sgroup "VDDGEN_PERPH_SUBTYPE (at 0x3c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VDDGEN_STATUS1"
      sgroup "VDDGEN_STATUS1 (at 0x3c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AVDD_RB                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AVDD_ENABLE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_PM                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DVDD_PM                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PVDD_RB                                  = " "0, 1"
    tree.end
    tree "VDDGEN_AUTO_TRIM_STATUS"
      sgroup "VDDGEN_AUTO_TRIM_STATUS (at 0x3c0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIM_COMP                                = " "0, 1"
    tree.end
    tree "VDDGEN_AVDD_REG_CTL"
      sgroup "VDDGEN_AVDD_REG_CTL (at 0x3c40)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   AVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_REF_OVR                             = " "0 (AUTO),1 (FORCE_MINI_BG)"
    tree.end
    tree "VDDGEN_DVDD_REG_CTL"
      sgroup "VDDGEN_DVDD_REG_CTL (at 0x3c41)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803c410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3c410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DVDD_MODE_CTRL                           = " "0 (LPM),1 (AUTOM),2 (HPM1),3 (HPM2)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   XVDD_DVDD_SRC_CTRL                       = " "0 (DVDD_SRC_FROM_LDO),1 (DVDD_SRC_FROM_SMPS),2 (DVDD_SRC_FROM_DVDDREG),3 (DVDD_SRC_FROM_DVDDREG1)"
    tree.end
    tree "VDDGEN_SEC_ACCESS"
      sgroup "VDDGEN_SEC_ACCESS (at 0x3cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VDDGEN_PERPH_RESET_CTL2"
      sgroup "VDDGEN_PERPH_RESET_CTL2 (at 0x3cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VDDGEN_PERPH_RESET_CTL3"
      sgroup "VDDGEN_PERPH_RESET_CTL3 (at 0x3cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VDDGEN_PERPH_RESET_CTL4"
      sgroup "VDDGEN_PERPH_RESET_CTL4 (at 0x3cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "VDDGEN_TEST1"
      sgroup "VDDGEN_TEST1 (at 0x3ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   RAW_AVDD_RB_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "VDDGEN_ATEST_SEL_TEST"
      sgroup "VDDGEN_ATEST_SEL_TEST (at 0x3ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST1_VBG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST2_DVDD_INT                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST1_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_VBG_BUFF                          = " "0, 1"
    tree.end
    tree "VDDGEN_VMAX_SEL_TEST"
      sgroup "VDDGEN_VMAX_SEL_TEST (at 0x3ce4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   VMAX_SEL                                 = "
    tree.end
    tree "VDDGEN_AVDD_RB_CTL"
      sgroup "VDDGEN_AVDD_RB_CTL (at 0x3ce5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   AVDD_RB_THRESH                           = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   AVDD_RB_GLITCH_FILT                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_AVDD_RB_OK                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SLEEP_B                           = " "0, 1"
    tree.end
    tree "VDDGEN_AVDD_DVDD_STABILITY_CTL"
      sgroup "VDDGEN_AVDD_DVDD_STABILITY_CTL (at 0x3ce6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   RZ_HPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   RZ_LPM                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "VDDGEN_AUTO_TRIM_CNTL"
      sgroup "VDDGEN_AUTO_TRIM_CNTL (at 0x3ce7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AUTO_TRIM_MODE                           = " "0 (reserved),1 (NON_AUTOTRIM),2 (MINIBG_AUTOTRIM),3 (AVDD_AUTOTRIM)"
    tree.end
    tree "VDDGEN_DTEST_SEL"
      sgroup "VDDGEN_DTEST_SEL (at 0x3ce8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VDDGEN_PVDD_RB_SEL"
      sgroup "VDDGEN_PVDD_RB_SEL (at 0x3ce9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803ce90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3ce90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PVDD_RB_SEL                              = " "0, 1"
    tree.end
    tree "VDDGEN_TRIM_NUM"
      sgroup "VDDGEN_TRIM_NUM (at 0x3cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "VDDGEN_MINI_BG_TRIM"
      sgroup "VDDGEN_MINI_BG_TRIM (at 0x3cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MINI_BG_TRIM                             = "
    tree.end
    tree "VDDGEN_AVDD_REG_TRIM"
      sgroup "VDDGEN_AVDD_REG_TRIM (at 0x3cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        set &access:&cmd_addr %l 0x803cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x3cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
  tree.end
tree.end
tree "VREF1"
  tree "VREF1"
    tree "VREF1_REVISION1"
      sgroup "VREF1_REVISION1 (at 0xa00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREF1_REVISION2"
      sgroup "VREF1_REVISION2 (at 0xa01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREF1_REVISION3"
      sgroup "VREF1_REVISION3 (at 0xa02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREF1_REVISION4"
      sgroup "VREF1_REVISION4 (at 0xa03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREF1_PERPH_TYPE"
      sgroup "VREF1_PERPH_TYPE (at 0xa04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREF1_PERPH_SUBTYPE"
      sgroup "VREF1_PERPH_SUBTYPE (at 0xa05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREF1_STATUS1"
      sgroup "VREF1_STATUS1 (at 0xa08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_LPDDR2_PERPH_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_LPDDR2_EN                           = " "0, 1"
    tree.end
    tree "VREF1_VREF_LPDDR2_EN"
      sgroup "VREF1_VREF_LPDDR2_EN (at 0xa44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0, 1"
    tree.end
    tree "VREF1_EN_CTL1"
      sgroup "VREF1_EN_CTL1 (at 0xa46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "VREF1_SEC_ACCESS"
      sgroup "VREF1_SEC_ACCESS (at 0xad0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREF1_PERPH_RESET_CTL1"
      sgroup "VREF1_PERPH_RESET_CTL1 (at 0xad8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VREF1_PERPH_RESET_CTL2"
      sgroup "VREF1_PERPH_RESET_CTL2 (at 0xad9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREF1_PERPH_RESET_CTL3"
      sgroup "VREF1_PERPH_RESET_CTL3 (at 0xada)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREF1_PERPH_RESET_CTL4"
      sgroup "VREF1_PERPH_RESET_CTL4 (at 0xadb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xadb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VREF1_TRIM_NUM"
      sgroup "VREF1_TRIM_NUM (at 0xaf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREF1_TRIM_VAL"
      sgroup "VREF1_TRIM_VAL (at 0xaf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        set &access:&cmd_addr %l 0x800af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xaf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_LPDDR2_TRIM_VALUE                   = "
    tree.end
  tree.end
tree.end
tree "VREF2"
  tree "VREF2"
    tree "VREF2_REVISION1"
      sgroup "VREF2_REVISION1 (at 0xb00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREF2_REVISION2"
      sgroup "VREF2_REVISION2 (at 0xb01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREF2_REVISION3"
      sgroup "VREF2_REVISION3 (at 0xb02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREF2_REVISION4"
      sgroup "VREF2_REVISION4 (at 0xb03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREF2_PERPH_TYPE"
      sgroup "VREF2_PERPH_TYPE (at 0xb04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREF2_PERPH_SUBTYPE"
      sgroup "VREF2_PERPH_SUBTYPE (at 0xb05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREF2_STATUS1"
      sgroup "VREF2_STATUS1 (at 0xb08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_MDM_PERPH_EN                        = " "0 (PERPH_EN_LOW),1 (PERPH_EN_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_MDM_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "VREF2_VREF_MDM_EN"
      sgroup "VREF2_VREF_MDM_EN (at 0xb44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (REF_DISABLED),1 (REF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LPM_EN                                   = " "0 (LPM_DISABLED),1 (LPM_ENABLED)"
    tree.end
    tree "VREF2_EN_CTL1"
      sgroup "VREF2_EN_CTL1 (at 0xb46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xb460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "VREF2_SEC_ACCESS"
      sgroup "VREF2_SEC_ACCESS (at 0xbd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREF2_PERPH_RESET_CTL1"
      sgroup "VREF2_PERPH_RESET_CTL1 (at 0xbd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VREF2_PERPH_RESET_CTL2"
      sgroup "VREF2_PERPH_RESET_CTL2 (at 0xbd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREF2_PERPH_RESET_CTL3"
      sgroup "VREF2_PERPH_RESET_CTL3 (at 0xbda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREF2_PERPH_RESET_CTL4"
      sgroup "VREF2_PERPH_RESET_CTL4 (at 0xbdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        set &access:&cmd_addr %l 0x800bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xb00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xbdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "VREF3"
  tree "VREF3"
    tree "VREF3_REVISION1"
      sgroup "VREF3_REVISION1 (at 0xc00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VREF3_REVISION2"
      sgroup "VREF3_REVISION2 (at 0xc01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VREF3_REVISION3"
      sgroup "VREF3_REVISION3 (at 0xc02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VREF3_REVISION4"
      sgroup "VREF3_REVISION4 (at 0xc03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VREF3_PERPH_TYPE"
      sgroup "VREF3_PERPH_TYPE (at 0xc04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VREF3_PERPH_SUBTYPE"
      sgroup "VREF3_PERPH_SUBTYPE (at 0xc05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VREF3_STATUS1"
      sgroup "VREF3_STATUS1 (at 0xc08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREF_WTR_PERPH_EN                        = " "0 (PERPH_EN_LOW),1 (PERPH_EN_HIGH)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREF_WTR_EN                              = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "VREF3_VREF_WTR_EN"
      sgroup "VREF3_VREF_WTR_EN (at 0xc44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (REF_DISABLED),1 (REF_ENABLED)"
    tree.end
    tree "VREF3_EN_CTL1"
      sgroup "VREF3_EN_CTL1 (at 0xc46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xc460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0 (DISABLED),1 (ENABLED)"
    tree.end
    tree "VREF3_SEC_ACCESS"
      sgroup "VREF3_SEC_ACCESS (at 0xcd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VREF3_PERPH_RESET_CTL1"
      sgroup "VREF3_PERPH_RESET_CTL1 (at 0xcd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "VREF3_PERPH_RESET_CTL2"
      sgroup "VREF3_PERPH_RESET_CTL2 (at 0xcd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "VREF3_PERPH_RESET_CTL3"
      sgroup "VREF3_PERPH_RESET_CTL3 (at 0xcda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "VREF3_PERPH_RESET_CTL4"
      sgroup "VREF3_PERPH_RESET_CTL4 (at 0xcdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "VREF3_TRIM_NUM"
      sgroup "VREF3_TRIM_NUM (at 0xcf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VREF3_TRIM_VAL"
      sgroup "VREF3_TRIM_VAL (at 0xcf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        set &access:&cmd_addr %l 0x800cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xc00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xcf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VREF_WTR_TRIM_VALUE                      = "
    tree.end
  tree.end
tree.end
tree "XO"
  tree "XO"
    tree "XO_REVISION1"
      sgroup "XO_REVISION1 (at 0x5000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "XO_REVISION2"
      sgroup "XO_REVISION2 (at 0x5001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "XO_REVISION3"
      sgroup "XO_REVISION3 (at 0x5002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "XO_REVISION4"
      sgroup "XO_REVISION4 (at 0x5003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "XO_PERPH_TYPE"
      sgroup "XO_PERPH_TYPE (at 0x5004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "XO_PERPH_SUBTYPE"
      sgroup "XO_PERPH_SUBTYPE (at 0x5005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "XO_STATUS1"
      sgroup "XO_STATUS1 (at 0x5008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_OK                                    = " "0 (XO_OFF),1 (XO_ON)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HW_SLEEP_B                               = " "0 (PMIC_HW_SLEEP),1 (PMIC_HW_AWAKE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_VREG_OK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_VREG_OK                               = " "0, 1"
    tree.end
    tree "XO_VOLTAGE_CTL1"
      sgroup "XO_VOLTAGE_CTL1 (at 0x5040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MUX_CTL                                  = " "0 (AUTO),1 (VREG_XO),2 (VREG_SMPS),3 (XVDD)"
    tree.end
    tree "XO_LDO_RF_VOLTAGE_CTL2"
      sgroup "XO_LDO_RF_VOLTAGE_CTL2 (at 0x5042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RF_VSET                                  = "
    tree.end
    tree "XO_LDO_XO_VOLTAGE_CTL2"
      sgroup "XO_LDO_XO_VOLTAGE_CTL2 (at 0x5043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_VSET                                  = "
    tree.end
    tree "XO_MODE_CTL1"
      sgroup "XO_MODE_CTL1 (at 0x5044)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_PREBUFF_MODE                          = " "0 (NPM),1 (HPM)"
    tree.end
    tree "XO_EN_CTL"
      sgroup "XO_EN_CTL (at 0x5046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN                                    = " "0 (XO_NOT_FORCED),1 (XO_FORCED_ON)"
    tree.end
    tree "XO_LDO_RF_EN_CTL"
      sgroup "XO_LDO_RF_EN_CTL (at 0x5047)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RF_EN_LDO_INT                            = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
    tree.end
    tree "XO_LDO_XO_EN_CTL"
      sgroup "XO_LDO_XO_EN_CTL (at 0x5048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_EN_LDO_INT                            = " "0 (LDO_NOT_FORCE_ENABLED),1 (LDO_FORCE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_ALT_CLK_EN                        = " "0 (NOT_FOLLOW_ALT_ENABLED),1 (FOLLOW_ALT_CLK_ENABLED)"
    tree.end
    tree "XO_LDO_RF_PD_CTL"
      sgroup "XO_LDO_RF_PD_CTL (at 0x5049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_PULLDN_EN                             = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "XO_LDO_XO_PD_CTL"
      sgroup "XO_LDO_XO_PD_CTL (at 0x504a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_PULLDN_EN                             = " "0 (PULLDN_DIABLED),1 (PULLDN_ENABLED)"
    tree.end
    tree "XO_XO_FREQ"
      sgroup "XO_XO_FREQ (at 0x504b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_FREQ                                  = " "0 (XO_LOW_FREQ),1 (XO_HIGH_FREQ)"
    tree.end
    tree "XO_XO_TIMER1"
      sgroup "XO_XO_TIMER1 (at 0x504c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DELAY                                    = "
    tree.end
    tree "XO_LDO_RF_LOW_PWR_CTL"
      sgroup "XO_LDO_RF_LOW_PWR_CTL (at 0x504d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RF_FORCE                                 = " "0 (NOT_FORCE_ENABLED),1 (FORCE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RF_FOLLOW_HW                             = " "0 (NOT_FOLLOW_HW),1 (FOLLOW_HW)"
    tree.end
    tree "XO_LDO_XO_LOW_PWR_CTL"
      sgroup "XO_LDO_XO_LOW_PWR_CTL (at 0x504e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_FORCE                                 = " "0 (NOT_FORCE_ENABLED),1 (FORCE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO_FOLLOW_HW                             = " "0 (NOT_FOLLOW_HW),1 (FOLLOW_HW)"
    tree.end
    tree "XO_LDO_XO_VREF_EN_CTL"
      sgroup "XO_LDO_XO_VREF_EN_CTL (at 0x504f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80504f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x504f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_VREF_EN_LDO_INT                       = " "0 (LDO_NOT_FORCE_VREF_ENABLED),1 (LDO_FORCE_VREF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_XO_VREF_EN                        = " "0 (NOT_FOLLOW_VREF_ENABLED),1 (FOLLOW_VREF_ENABLED)"
    tree.end
    tree "XO_LDO_RF_VREF_EN_CTL"
      sgroup "XO_LDO_RF_VREF_EN_CTL (at 0x5050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RF_VREF_EN_LDO_INT                       = " "0 (LDO_NOT_FORCE_VREF_ENABLED),1 (LDO_FORCE_VREF_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_RF_VREF_EN                        = " "0 (NOT_FOLLOW_VREF_ENABLED),1 (FOLLOW_VREF_ENABLED)"
    tree.end
    tree "XO_SPARE1"
      sgroup "XO_SPARE1 (at 0x5051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "XO_SPARE2"
      sgroup "XO_SPARE2 (at 0x5052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "XO_SPARE3"
      sgroup "XO_SPARE3 (at 0x5053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "XO_XO_COMP"
      sgroup "XO_XO_COMP (at 0x5058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CAP_VAL                                  = "
    tree.end
    tree "XO_XO_COMP_CTL"
      sgroup "XO_XO_COMP_CTL (at 0x5059)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   COMP_EN                                  = " "0 (XO_COMP_CAP_FOLLOW_HARDWARE),1 (XO_COMP_CAP_FORCED_ON)"
    tree.end
    tree "XO_XO_STEPPER"
      sgroup "XO_XO_STEPPER (at 0x505a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO_FAST_START_EN                         = " "0 (XO_FASTSTART_DIS),1 (XO_FAST_START_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SS_RATE                                  = " "0 (TCXO_DIV_8),1 (TCXO_DIV_16),2 (TCXO_DIV_128),3 (TCXO_DIV_256)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   XO_FAST_START_DLY                        = "
    tree.end
    tree "XO_XO_ADJ_FINE"
      sgroup "XO_XO_ADJ_FINE (at 0x505c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   XO_ADJUST_CAP                            = "
    tree.end
    tree "XO_ICTL"
      sgroup "XO_ICTL (at 0x505e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x80505e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x505e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   MISSION                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SLEEP                                    = "
    tree.end
    tree "XO_SEC_ACCESS"
      sgroup "XO_SEC_ACCESS (at 0x50d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "XO_PERPH_RESET_CTL2"
      sgroup "XO_PERPH_RESET_CTL2 (at 0x50d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL3"
      sgroup "XO_PERPH_RESET_CTL3 (at 0x50da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "XO_PERPH_RESET_CTL4"
      sgroup "XO_PERPH_RESET_CTL4 (at 0x50db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NO_RESET),1 (LOCAL_SOFT_RESET)"
    tree.end
    tree "XO_TEST1"
      sgroup "XO_TEST1 (at 0x50e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   DTEST1_SEL                               = " "0 (HIZ),1 (RAW_XO_CLK),2 (OUTBUFF_EN),3 (OUTBUFF_EN_DLY),4 (STEPPER_DONE),5 (SLEEP_B),6 (reserved),7 (reserved)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   XO_AGC_TEST_EN                           = " "0 (ATEST1_HI_Z),1 (XO_AGC_ON_ATEST)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ADJ_CODE_TEST                            = " "0 (GRAY_CODE),1 (BINARY_CODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SS_RESET                                 = " "0 (NORMAL),1 (RESET_STEPPER)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RF_PREBUF_FOLLOW_BB                      = " "0 (RFPREBUFF_NOT_FOLLOW_BB),1 (RFPREBUFF_FOLLOW_BB)"
    tree.end
    tree "XO_TEST2"
      sgroup "XO_TEST2 (at 0x50e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RF_OUT_DTEST                             = " "0 (DRIVE_RF_NORMAL),1 (DRIVE_RF_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   RF_OUT_TEST                              = " "0 (RF_NORMAL),1 (RF_DISABLED),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BB_OUT_DTEST                             = " "0 (DRIVE_BB_NORMAL),1 (DRIVE_BB_FROM_DTEST2)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BB_OUT_TEST                              = " "0 (BB_NORMAL),1 (BB_DISABLED),2 (reserved),3 (reserved)"
    tree.end
    tree "XO_TEST3"
      sgroup "XO_TEST3 (at 0x50e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LDO_RF_ATEST                             = " "0 (ATEST_HIGHZ),1 (ATEST_VREG_OUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LDO_XO_ATEST                             = " "0 (ATEST_HIGHZ),1 (ATEST_VREG_OUT)"
    tree.end
    tree "XO_TEST4"
      sgroup "XO_TEST4 (at 0x50e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        set &access:&cmd_addr %l 0x8050e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x50e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LNBBCLK_EQUAL_XO                         = " "0 (NOT_EQUAL_XO),1 (EQUAL_XO)"
    tree.end
  tree.end
tree.end

