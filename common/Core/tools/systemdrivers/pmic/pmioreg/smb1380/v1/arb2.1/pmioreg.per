entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "I2C_SS_DIG"
  tree "I2C_SS_DIG"
    tree "I2C_SS_DIG_REVISION1"
      sgroup "I2C_SS_DIG_REVISION1 (at 0xe00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "I2C_SS_DIG_REVISION2"
      sgroup "I2C_SS_DIG_REVISION2 (at 0xe01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "I2C_SS_DIG_REVISION3"
      sgroup "I2C_SS_DIG_REVISION3 (at 0xe02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "I2C_SS_DIG_REVISION4"
      sgroup "I2C_SS_DIG_REVISION4 (at 0xe03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "I2C_SS_DIG_PERPH_TYPE"
      sgroup "I2C_SS_DIG_PERPH_TYPE (at 0xe04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "I2C_SS_DIG_PERPH_SUBTYPE"
      sgroup "I2C_SS_DIG_PERPH_SUBTYPE (at 0xe05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "I2C_SS_DIG_I2C_SID"
      sgroup "I2C_SS_DIG_I2C_SID (at 0xe44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   I2C_SID_MSB                              = "
    tree.end
    tree "I2C_SS_DIG_PMIC_SID"
      sgroup "I2C_SS_DIG_PMIC_SID (at 0xe45)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PMIC_SID3                                = " "0 (NO_SID3),1 (SID3)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_SID2                                = " "0 (NO_SID2),1 (SID2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PMIC_SID1                                = " "0 (NO_SID1),1 (SID1)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PMIC_SID0                                = " "0 (NO_SID0),1 (SID0)"
    tree.end
    tree "I2C_SS_DIG_SAMPLE_EDGE"
      sgroup "I2C_SS_DIG_SAMPLE_EDGE (at 0xe46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USE_RISING_EDGE                          = " "0 (FALLING_EDGE_SCL),1 (RISING_EDGE_SCL)"
    tree.end
    tree "I2C_SS_DIG_I2C_LOWI_OVERRIDE"
      sgroup "I2C_SS_DIG_I2C_LOWI_OVERRIDE (at 0xe47)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800e470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xe470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DISABLE                                  = " "0, 1"
    tree.end
    tree "I2C_SS_DIG_SEC_ACCESS"
      sgroup "I2C_SS_DIG_SEC_ACCESS (at 0xed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "I2C_SS_DIG_PERPH_RESET_CTL2"
      sgroup "I2C_SS_DIG_PERPH_RESET_CTL2 (at 0xed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "I2C_SS_DIG_PERPH_RESET_CTL3"
      sgroup "I2C_SS_DIG_PERPH_RESET_CTL3 (at 0xeda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "I2C_SS_DIG_PERPH_RESET_CTL4"
      sgroup "I2C_SS_DIG_PERPH_RESET_CTL4 (at 0xedb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "I2C_SS_DIG_TEST1"
      sgroup "I2C_SS_DIG_TEST1 (at 0xee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800ee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4_EN                                = " "0 (DTEST4_DISABLED),1 (DTEST4_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3_EN                                = " "0 (DTEST3_DISABLED),1 (DTEST3_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2_EN                                = " "0 (DTEST2_DISABLED),1 (DTEST2_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1_EN                                = " "0 (DTEST1_DISABLED),1 (DTEST1_ENABLED)"
    tree.end
    tree "I2C_SS_DIG_TEST2"
      sgroup "I2C_SS_DIG_TEST2 (at 0xee3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800ee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DTEST4_SEL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DTEST3_SEL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DTEST2_SEL                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST1_SEL                               = " "0, 1, 2, 3"
    tree.end
    tree "I2C_SS_DIG_ATE_MODE_SEL"
      sgroup "I2C_SS_DIG_ATE_MODE_SEL (at 0xee4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800ee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DISABLE_GLITCH_FILTER                    = " "0, 1"
    tree.end
    tree "I2C_SS_DIG_I2C_ALWAYS_ON"
      sgroup "I2C_SS_DIG_I2C_ALWAYS_ON (at 0xee5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        set &access:&cmd_addr %l 0x800ee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALWAYS_ON                                = " "0, 1"
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IRQ_STATUS                               = " "0 (NO_INT_CLOCK_REQ),1 (INT_CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0 (NO_CLOCK_REQ),1 (CLOCK_REQUESTED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0 (NO_SEND_REQ),1 (SEND_REQUESTED)"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0 (reserved),1 (RESEND_ALL)"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0 (PERIPHERAL_DISABLED),1 (PERIPHERAL_ENABLED)"
    tree.end
    tree "INT_I2C_INTR_STATUS1"
      sgroup "INT_I2C_INTR_STATUS1 (at 0x550)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TADC                                     = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SMB2CHG_MISC                             = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SMB2CHG_DC                               = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SMB2CHG_USB                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SMB2CHG_BATIF                            = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMB2CHG_OTG                              = " "0 (IRQ_OFF),1 (IRQ_ON)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMB2CHG_CHGR                             = " "0 (IRQ_OFF),1 (IRQ_ON)"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_STATUS2"
      sgroup "MISC_STATUS2 (at 0x909)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
    tree "MISC_FTRIM_HDR1_I2C_SS_BYTE1"
      sgroup "MISC_FTRIM_HDR1_I2C_SS_BYTE1 (at 0x920)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009200
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9200
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_I2C_SS_BYTE2"
      sgroup "MISC_FTRIM_HDR1_I2C_SS_BYTE2 (at 0x921)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009210
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9210
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_I2C_SS_BYTE3"
      sgroup "MISC_FTRIM_HDR1_I2C_SS_BYTE3 (at 0x922)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009220
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9220
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR1_MISC_BYTE1"
      sgroup "MISC_ATRIM_HDR1_MISC_BYTE1 (at 0x923)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009230
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9230
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR1_MISC_BYTE2"
      sgroup "MISC_ATRIM_HDR1_MISC_BYTE2 (at 0x924)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009240
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9240
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR1_MISC_BYTE3"
      sgroup "MISC_ATRIM_HDR1_MISC_BYTE3 (at 0x925)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009250
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9250
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR1_REVID_BYTE1"
      sgroup "MISC_ATRIM_HDR1_REVID_BYTE1 (at 0x926)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009260
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9260
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR1_REVID_BYTE2"
      sgroup "MISC_ATRIM_HDR1_REVID_BYTE2 (at 0x927)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009270
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9270
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR1_REVID_BYTE3"
      sgroup "MISC_ATRIM_HDR1_REVID_BYTE3 (at 0x928)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009280
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9280
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_TADC_BYTE1"
      sgroup "MISC_FTRIM_HDR1_TADC_BYTE1 (at 0x929)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009290
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9290
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_TADC_BYTE2"
      sgroup "MISC_FTRIM_HDR1_TADC_BYTE2 (at 0x92a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80092a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x92a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_TADC_BYTE3"
      sgroup "MISC_FTRIM_HDR1_TADC_BYTE3 (at 0x92b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80092b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x92b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR2_TADC_BYTE1"
      sgroup "MISC_ATRIM_HDR2_TADC_BYTE1 (at 0x92c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80092c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x92c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR2_TADC_BYTE2"
      sgroup "MISC_ATRIM_HDR2_TADC_BYTE2 (at 0x92d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80092d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x92d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR2_TADC_BYTE3"
      sgroup "MISC_ATRIM_HDR2_TADC_BYTE3 (at 0x92e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80092e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x92e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_TADC_CMP_THR1_BYTE1"
      sgroup "MISC_FTRIM_HDR1_TADC_CMP_THR1_BYTE1 (at 0x92f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80092f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x92f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_TADC_CMP_THR1_BYTE2"
      sgroup "MISC_FTRIM_HDR1_TADC_CMP_THR1_BYTE2 (at 0x930)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009300
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9300
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_TADC_CMP_THR1_BYTE3"
      sgroup "MISC_FTRIM_HDR1_TADC_CMP_THR1_BYTE3 (at 0x931)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009310
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9310
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_TADC_CMP_THR2_BYTE1"
      sgroup "MISC_FTRIM_HDR2_TADC_CMP_THR2_BYTE1 (at 0x932)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009320
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9320
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_TADC_CMP_THR2_BYTE2"
      sgroup "MISC_FTRIM_HDR2_TADC_CMP_THR2_BYTE2 (at 0x933)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009330
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9330
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR2_TADC_CMP_THR2_BYTE3"
      sgroup "MISC_FTRIM_HDR2_TADC_CMP_THR2_BYTE3 (at 0x934)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009340
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9340
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_TADC_CMP_THR3_BYTE1"
      sgroup "MISC_FTRIM_HDR3_TADC_CMP_THR3_BYTE1 (at 0x935)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009350
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9350
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_TADC_CMP_THR3_BYTE2"
      sgroup "MISC_FTRIM_HDR3_TADC_CMP_THR3_BYTE2 (at 0x936)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009360
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9360
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR3_TADC_CMP_THR3_BYTE3"
      sgroup "MISC_FTRIM_HDR3_TADC_CMP_THR3_BYTE3 (at 0x937)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009370
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9370
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_TADC_CMP_THR4_BYTE1"
      sgroup "MISC_FTRIM_HDR4_TADC_CMP_THR4_BYTE1 (at 0x938)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009380
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9380
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_TADC_CMP_THR4_BYTE2"
      sgroup "MISC_FTRIM_HDR4_TADC_CMP_THR4_BYTE2 (at 0x939)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009390
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9390
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR4_TADC_CMP_THR4_BYTE3"
      sgroup "MISC_FTRIM_HDR4_TADC_CMP_THR4_BYTE3 (at 0x93a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80093a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x93a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_TADC_CMP_CH1_HYST_BYTE1"
      sgroup "MISC_FTRIM_HDR4_TADC_CMP_CH1_HYST_BYTE1 (at 0x93b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80093b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x93b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_TADC_CMP_CH1_HYST_BYTE2"
      sgroup "MISC_FTRIM_HDR4_TADC_CMP_CH1_HYST_BYTE2 (at 0x93c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80093c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x93c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR4_TADC_CMP_CH1_HYST_BYTE3"
      sgroup "MISC_FTRIM_HDR4_TADC_CMP_CH1_HYST_BYTE3 (at 0x93d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80093d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x93d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_CHGR_BYTE1 (at 0x93e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80093e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x93e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_CHGR_BYTE2 (at 0x93f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80093f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x93f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_CHGR_BYTE3 (at 0x940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_CHGR_BYTE1 (at 0x941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_CHGR_BYTE2 (at 0x942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_CHGR_BYTE3 (at 0x943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_CHGR_BYTE1 (at 0x944)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_CHGR_BYTE2 (at 0x945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_CHGR_BYTE3 (at 0x946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_CHGR_BYTE1 (at 0x947)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_CHGR_BYTE2 (at 0x948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_CHGR_BYTE3 (at 0x949)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_CHGR_BYTE1 (at 0x94a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_CHGR_BYTE2 (at 0x94b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_CHGR_BYTE3 (at 0x94c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_CHGR_BYTE1 (at 0x94d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_CHGR_BYTE2 (at 0x94e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_CHGR_BYTE3 (at 0x94f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80094f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x94f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR7_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_FTRIM_HDR7_SMBCHG_CHGR_BYTE1 (at 0x950)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR7_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_FTRIM_HDR7_SMBCHG_CHGR_BYTE2 (at 0x951)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR7_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_FTRIM_HDR7_SMBCHG_CHGR_BYTE3 (at 0x952)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR8_SMBCHG_CHGR_BYTE1"
      sgroup "MISC_ATRIM_HDR8_SMBCHG_CHGR_BYTE1 (at 0x953)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR8_SMBCHG_CHGR_BYTE2"
      sgroup "MISC_ATRIM_HDR8_SMBCHG_CHGR_BYTE2 (at 0x954)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR8_SMBCHG_CHGR_BYTE3"
      sgroup "MISC_ATRIM_HDR8_SMBCHG_CHGR_BYTE3 (at 0x955)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_OTG_BYTE1"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_OTG_BYTE1 (at 0x956)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_OTG_BYTE2"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_OTG_BYTE2 (at 0x957)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_OTG_BYTE3"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_OTG_BYTE3 (at 0x958)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR3_SMBCHG_OTG_BYTE1"
      sgroup "MISC_ATRIM_HDR3_SMBCHG_OTG_BYTE1 (at 0x959)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR3_SMBCHG_OTG_BYTE2"
      sgroup "MISC_ATRIM_HDR3_SMBCHG_OTG_BYTE2 (at 0x95a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80095a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x95a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR3_SMBCHG_OTG_BYTE3"
      sgroup "MISC_ATRIM_HDR3_SMBCHG_OTG_BYTE3 (at 0x95b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80095b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x95b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_BAT_IF_BYTE1"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_BAT_IF_BYTE1 (at 0x95c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80095c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x95c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_BAT_IF_BYTE2"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_BAT_IF_BYTE2 (at 0x95d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80095d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x95d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_BAT_IF_BYTE3"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_BAT_IF_BYTE3 (at 0x95e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80095e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x95e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_BAT_IF_BYTE1"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_BAT_IF_BYTE1 (at 0x95f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80095f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x95f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_BAT_IF_BYTE2"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_BAT_IF_BYTE2 (at 0x960)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_BAT_IF_BYTE3"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_BAT_IF_BYTE3 (at 0x961)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_BAT_IF_BYTE1"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_BAT_IF_BYTE1 (at 0x962)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_BAT_IF_BYTE2"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_BAT_IF_BYTE2 (at 0x963)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_BAT_IF_BYTE3"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_BAT_IF_BYTE3 (at 0x964)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_BAT_IF_BYTE1"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_BAT_IF_BYTE1 (at 0x965)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_BAT_IF_BYTE2"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_BAT_IF_BYTE2 (at 0x966)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_BAT_IF_BYTE3"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_BAT_IF_BYTE3 (at 0x967)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR5_SMBCHG_BAT_IF_BYTE1"
      sgroup "MISC_ATRIM_HDR5_SMBCHG_BAT_IF_BYTE1 (at 0x968)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR5_SMBCHG_BAT_IF_BYTE2"
      sgroup "MISC_ATRIM_HDR5_SMBCHG_BAT_IF_BYTE2 (at 0x969)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR5_SMBCHG_BAT_IF_BYTE3"
      sgroup "MISC_ATRIM_HDR5_SMBCHG_BAT_IF_BYTE3 (at 0x96a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80096a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x96a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_USB_BYTE1"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_USB_BYTE1 (at 0x96b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80096b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x96b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_USB_BYTE2"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_USB_BYTE2 (at 0x96c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80096c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x96c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_USB_BYTE3"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_USB_BYTE3 (at 0x96d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80096d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x96d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_USB_BYTE1"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_USB_BYTE1 (at 0x96e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80096e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x96e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_USB_BYTE2"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_USB_BYTE2 (at 0x96f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80096f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x96f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_USB_BYTE3"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_USB_BYTE3 (at 0x970)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_USB_BYTE1"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_USB_BYTE1 (at 0x971)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_USB_BYTE2"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_USB_BYTE2 (at 0x972)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_USB_BYTE3"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_USB_BYTE3 (at 0x973)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_USB_BYTE1"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_USB_BYTE1 (at 0x974)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_USB_BYTE2"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_USB_BYTE2 (at 0x975)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_USB_BYTE3"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_USB_BYTE3 (at 0x976)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_USB_BYTE1"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_USB_BYTE1 (at 0x977)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_USB_BYTE2"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_USB_BYTE2 (at 0x978)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_USB_BYTE3"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_USB_BYTE3 (at 0x979)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_USB_BYTE1"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_USB_BYTE1 (at 0x97a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80097a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x97a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_USB_BYTE2"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_USB_BYTE2 (at 0x97b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80097b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x97b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_USB_BYTE3"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_USB_BYTE3 (at 0x97c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80097c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x97c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_USB_BYTE1"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_USB_BYTE1 (at 0x97d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80097d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x97d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_USB_BYTE2"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_USB_BYTE2 (at 0x97e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80097e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x97e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_USB_BYTE3"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_USB_BYTE3 (at 0x97f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80097f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x97f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_DC_BYTE1"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_DC_BYTE1 (at 0x980)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_DC_BYTE2"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_DC_BYTE2 (at 0x981)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_DC_BYTE3"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_DC_BYTE3 (at 0x982)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_DC_BYTE1"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_DC_BYTE1 (at 0x983)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_DC_BYTE2"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_DC_BYTE2 (at 0x984)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_DC_BYTE3"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_DC_BYTE3 (at 0x985)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_DC_BYTE1"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_DC_BYTE1 (at 0x986)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009860
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9860
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_DC_BYTE2"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_DC_BYTE2 (at 0x987)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009870
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9870
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_DC_BYTE3"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_DC_BYTE3 (at 0x988)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_DC_BYTE1"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_DC_BYTE1 (at 0x989)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_DC_BYTE2"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_DC_BYTE2 (at 0x98a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80098a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x98a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_DC_BYTE3"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_DC_BYTE3 (at 0x98b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80098b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x98b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_DC_BYTE1"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_DC_BYTE1 (at 0x98c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80098c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x98c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_DC_BYTE2"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_DC_BYTE2 (at 0x98d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80098d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x98d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_DC_BYTE3"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_DC_BYTE3 (at 0x98e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80098e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x98e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR7_SMBCHG_DC_BYTE1"
      sgroup "MISC_FTRIM_HDR7_SMBCHG_DC_BYTE1 (at 0x98f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80098f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x98f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR7_SMBCHG_DC_BYTE2"
      sgroup "MISC_FTRIM_HDR7_SMBCHG_DC_BYTE2 (at 0x990)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR7_SMBCHG_DC_BYTE3"
      sgroup "MISC_FTRIM_HDR7_SMBCHG_DC_BYTE3 (at 0x991)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR8_SMBCHG_DC_BYTE1"
      sgroup "MISC_FTRIM_HDR8_SMBCHG_DC_BYTE1 (at 0x992)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR8_SMBCHG_DC_BYTE2"
      sgroup "MISC_FTRIM_HDR8_SMBCHG_DC_BYTE2 (at 0x993)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR8_SMBCHG_DC_BYTE3"
      sgroup "MISC_FTRIM_HDR8_SMBCHG_DC_BYTE3 (at 0x994)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_DC_BYTE1"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_DC_BYTE1 (at 0x995)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_DC_BYTE2"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_DC_BYTE2 (at 0x996)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_DC_BYTE3"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_DC_BYTE3 (at 0x997)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_MISC_BYTE1"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_MISC_BYTE1 (at 0x998)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009980
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9980
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_MISC_BYTE2"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_MISC_BYTE2 (at 0x999)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009990
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9990
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR1_SMBCHG_MISC_BYTE3"
      sgroup "MISC_FTRIM_HDR1_SMBCHG_MISC_BYTE3 (at 0x99a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80099a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x99a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_MISC_BYTE1"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_MISC_BYTE1 (at 0x99b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80099b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x99b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_MISC_BYTE2"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_MISC_BYTE2 (at 0x99c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80099c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x99c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR2_SMBCHG_MISC_BYTE3"
      sgroup "MISC_FTRIM_HDR2_SMBCHG_MISC_BYTE3 (at 0x99d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80099d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x99d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_MISC_BYTE1"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_MISC_BYTE1 (at 0x99e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80099e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x99e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_MISC_BYTE2"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_MISC_BYTE2 (at 0x99f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x80099f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x99f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR3_SMBCHG_MISC_BYTE3"
      sgroup "MISC_FTRIM_HDR3_SMBCHG_MISC_BYTE3 (at 0x9a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_MISC_BYTE1"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_MISC_BYTE1 (at 0x9a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_MISC_BYTE2"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_MISC_BYTE2 (at 0x9a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR4_SMBCHG_MISC_BYTE3"
      sgroup "MISC_FTRIM_HDR4_SMBCHG_MISC_BYTE3 (at 0x9a3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_MISC_BYTE1"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_MISC_BYTE1 (at 0x9a4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_MISC_BYTE2"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_MISC_BYTE2 (at 0x9a5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR5_SMBCHG_MISC_BYTE3"
      sgroup "MISC_FTRIM_HDR5_SMBCHG_MISC_BYTE3 (at 0x9a6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_MISC_BYTE1"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_MISC_BYTE1 (at 0x9a7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_MISC_BYTE2"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_MISC_BYTE2 (at 0x9a8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR6_SMBCHG_MISC_BYTE3"
      sgroup "MISC_FTRIM_HDR6_SMBCHG_MISC_BYTE3 (at 0x9a9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009a90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9a90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_FTRIM_HDR8_SMBCHG_MISC_BYTE1"
      sgroup "MISC_FTRIM_HDR8_SMBCHG_MISC_BYTE1 (at 0x9aa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009aa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9aa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_FTRIM_HDR8_SMBCHG_MISC_BYTE2"
      sgroup "MISC_FTRIM_HDR8_SMBCHG_MISC_BYTE2 (at 0x9ab)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ab0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ab0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_FTRIM_HDR8_SMBCHG_MISC_BYTE3"
      sgroup "MISC_FTRIM_HDR8_SMBCHG_MISC_BYTE3 (at 0x9ac)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ac0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ac0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_MISC_BYTE1"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_MISC_BYTE1 (at 0x9ad)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ad0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ad0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_MISC_BYTE2"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_MISC_BYTE2 (at 0x9ae)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ae0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ae0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_ATRIM_HDR9_SMBCHG_MISC_BYTE3"
      sgroup "MISC_ATRIM_HDR9_SMBCHG_MISC_BYTE3 (at 0x9af)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009af0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9af0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_TRIM_HDR1_SPARE_BYTE1"
      sgroup "MISC_TRIM_HDR1_SPARE_BYTE1 (at 0x9b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_TRIM_HDR1_SPARE_BYTE2"
      sgroup "MISC_TRIM_HDR1_SPARE_BYTE2 (at 0x9b1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_TRIM_HDR1_SPARE_BYTE3"
      sgroup "MISC_TRIM_HDR1_SPARE_BYTE3 (at 0x9b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_TRIM_HDR2_SPARE_BYTE1"
      sgroup "MISC_TRIM_HDR2_SPARE_BYTE1 (at 0x9b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_TRIM_HDR2_SPARE_BYTE2"
      sgroup "MISC_TRIM_HDR2_SPARE_BYTE2 (at 0x9b4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_TRIM_HDR2_SPARE_BYTE3"
      sgroup "MISC_TRIM_HDR2_SPARE_BYTE3 (at 0x9b5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_TRIM_HDR3_SPARE_BYTE1"
      sgroup "MISC_TRIM_HDR3_SPARE_BYTE1 (at 0x9b6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_TRIM_HDR3_SPARE_BYTE2"
      sgroup "MISC_TRIM_HDR3_SPARE_BYTE2 (at 0x9b7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_TRIM_HDR3_SPARE_BYTE3"
      sgroup "MISC_TRIM_HDR3_SPARE_BYTE3 (at 0x9b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_TRIM_HDR4_SPARE_BYTE1"
      sgroup "MISC_TRIM_HDR4_SPARE_BYTE1 (at 0x9b9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_TRIM_HDR4_SPARE_BYTE2"
      sgroup "MISC_TRIM_HDR4_SPARE_BYTE2 (at 0x9ba)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_TRIM_HDR4_SPARE_BYTE3"
      sgroup "MISC_TRIM_HDR4_SPARE_BYTE3 (at 0x9bb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009bb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9bb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_TRIM_HDR1_END_BYTE1"
      sgroup "MISC_TRIM_HDR1_END_BYTE1 (at 0x9bc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009bc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9bc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PID                                      = "
    tree.end
    tree "MISC_TRIM_HDR1_END_BYTE2"
      sgroup "MISC_TRIM_HDR1_END_BYTE2 (at 0x9bd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009bd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9bd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OFFSET                                   = "
    tree.end
    tree "MISC_TRIM_HDR1_END_BYTE3"
      sgroup "MISC_TRIM_HDR1_END_BYTE3 (at 0x9be)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009be0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9be0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   SID                                      = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   NUM                                      = "
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x9e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0 (TEST_ACCESS_DISABLED),1 (TEST_ACCESS_ENABLED)"
    tree.end
    tree "MISC_HARD_RESET"
      sgroup "MISC_HARD_RESET (at 0x9e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_CTL                                   = " "0, 1"
    tree.end
    tree "MISC_GLOBAL_SOFT_RESET"
      sgroup "MISC_GLOBAL_SOFT_RESET (at 0x9e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_CTL                                   = " "0, 1"
    tree.end
    tree "MISC_WARM_RESET"
      sgroup "MISC_WARM_RESET (at 0x9e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_CTL                                   = " "0, 1"
    tree.end
    tree "MISC_CHIP_DTEST_DRV"
      sgroup "MISC_CHIP_DTEST_DRV (at 0x9e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN                                       = "
    tree.end
    tree "MISC_CHIP_DTEST"
      sgroup "MISC_CHIP_DTEST (at 0x9e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OUTPIN4_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OUTPIN3_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OUTPIN2_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OUTPIN1_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MISC_FAST_TSTCLK"
      sgroup "MISC_FAST_TSTCLK (at 0x9e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TADC                                     = " "0, 1"
    tree.end
    tree "MISC_TRIM_NUM"
      sgroup "MISC_TRIM_NUM (at 0x9f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "MISC_CSIR_7_0"
      sgroup "MISC_CSIR_7_0 (at 0x9f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CSIR_7_0                                 = "
    tree.end
    tree "MISC_CSIR_15_8"
      sgroup "MISC_CSIR_15_8 (at 0x9f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CSIR_15_8                                = "
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_SBL_ID_0"
      sgroup "REVID_SBL_ID_0 (at 0x150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_SBL_ID_1"
      sgroup "REVID_SBL_ID_1 (at 0x151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VERSION                                  = "
    tree.end
    tree "REVID_REV_ID_SPARE_0"
      sgroup "REVID_REV_ID_SPARE_0 (at 0x160)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID_REV_ID_SPARE_1"
      sgroup "REVID_REV_ID_SPARE_1 (at 0x161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TRIM_NUM"
      sgroup "REVID_TRIM_NUM (at 0x1f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "REVID_TP_REV"
      sgroup "REVID_TP_REV (at 0x1f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TP_REV                                   = "
    tree.end
    tree "REVID_FAB_ID"
      sgroup "REVID_FAB_ID (at 0x1f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FAB_ID                                   = "
    tree.end
    tree "REVID_WAFER_ID"
      sgroup "REVID_WAFER_ID (at 0x1f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   WAFER_ID                                 = "
    tree.end
    tree "REVID_X_COORD"
      sgroup "REVID_X_COORD (at 0x1f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   X_COORD                                  = "
    tree.end
    tree "REVID_Y_COORD"
      sgroup "REVID_Y_COORD (at 0x1f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   Y_COORD                                  = "
    tree.end
    tree "REVID_LOT_ID_11_10"
      sgroup "REVID_LOT_ID_11_10 (at 0x1f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_11_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_10_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_10_09"
      sgroup "REVID_LOT_ID_10_09 (at 0x1f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_10_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_09_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_09_08"
      sgroup "REVID_LOT_ID_09_08 (at 0x1f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_09_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_08_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_07_06"
      sgroup "REVID_LOT_ID_07_06 (at 0x1f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_07_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_06_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_06_05"
      sgroup "REVID_LOT_ID_06_05 (at 0x1fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_06_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_05_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_05_04"
      sgroup "REVID_LOT_ID_05_04 (at 0x1fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_05_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_04_5_0                            = "
    tree.end
    tree "REVID_LOT_ID_03_02"
      sgroup "REVID_LOT_ID_03_02 (at 0x1fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   LOT_ID_03_5_0                            = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LOT_ID_02_5_4                            = " "0, 1, 2, 3"
    tree.end
    tree "REVID_LOT_ID_02_01"
      sgroup "REVID_LOT_ID_02_01 (at 0x1fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LOT_ID_02_3_0                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOT_ID_01_5_2                            = "
    tree.end
    tree "REVID_LOT_ID_01_00"
      sgroup "REVID_LOT_ID_01_00 (at 0x1fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   LOT_ID_01_1_0                            = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   LOT_ID_00_5_0                            = "
    tree.end
    tree "REVID_MFG_ID_SPARE"
      sgroup "REVID_MFG_ID_SPARE (at 0x1ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
  tree.end
tree.end
tree "SMB2CHG_BATIF"
  tree "SMB2CHG_BATIF"
    tree "SMB2CHG_BATIF_PERPH_TYPE"
      sgroup "SMB2CHG_BATIF_PERPH_TYPE (at 0x1204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMB2CHG_BATIF_PERPH_SUBTYPE"
      sgroup "SMB2CHG_BATIF_PERPH_SUBTYPE (at 0x1205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMB2CHG_BATIF_INT_RT_STS"
      sgroup "SMB2CHG_BATIF_INT_RT_STS (at 0x1210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_RT_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_RT_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_RT_STS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_RT_STS                          = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_SET_TYPE"
      sgroup "SMB2CHG_BATIF_INT_SET_TYPE (at 0x1211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_TYPE                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_TYPE             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_TYPE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_TYPE                            = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_POLARITY_HIGH"
      sgroup "SMB2CHG_BATIF_INT_POLARITY_HIGH (at 0x1212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_HIGH                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_HIGH             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_HIGH                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_HIGH                            = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_POLARITY_LOW"
      sgroup "SMB2CHG_BATIF_INT_POLARITY_LOW (at 0x1213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_LOW                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_LOW              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_LOW                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_LOW                             = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_LATCHED_CLR"
      sgroup "SMB2CHG_BATIF_INT_LATCHED_CLR (at 0x1214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_LATCHED_CLR      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_EN_SET"
      sgroup "SMB2CHG_BATIF_INT_EN_SET (at 0x1215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_EN_SET              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_EN_SET           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_EN_SET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_EN_SET                          = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_EN_CLR"
      sgroup "SMB2CHG_BATIF_INT_EN_CLR (at 0x1216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_EN_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_EN_CLR                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_LATCHED_STS"
      sgroup "SMB2CHG_BATIF_INT_LATCHED_STS (at 0x1218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_LATCHED_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_LATCHED_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_LATCHED_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_PENDING_STS"
      sgroup "SMB2CHG_BATIF_INT_PENDING_STS (at 0x1219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_PENDING_STS         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_PENDING_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_PENDING_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_MID_SEL"
      sgroup "SMB2CHG_BATIF_INT_MID_SEL (at 0x121a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_BATIF_INT_PRIORITY"
      sgroup "SMB2CHG_BATIF_INT_PRIORITY (at 0x121b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_SHIP_MODE"
      sgroup "SMB2CHG_BATIF_SHIP_MODE (at 0x1240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SHIP_MODE_EN                             = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_BATOCP_THRESHOLD_CFG"
      sgroup "SMB2CHG_BATIF_BATOCP_THRESHOLD_CFG (at 0x1250)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BATOCP_ENABLE_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATOCP_THRESHOLD                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_BATIF_BATOCP_INTRPT_DELAY_TMR_CFG"
      sgroup "SMB2CHG_BATIF_BATOCP_INTRPT_DELAY_TMR_CFG (at 0x1251)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   BATOCP_INTRPT_TIMEOUT                    = " "0 (BATOCP_INTRPT_TMOUT_1MS),1 (BATOCP_INTRPT_TMOUT_2MS),2 (BATOCP_INTRPT_TMOUT_3MS),3 (BATOCP_INTRPT_TMOUT_4MS),4 (BATOCP_INTRPT_TMOUT_5MS),5 (BATOCP_INTRPT_TMOUT_6MS),6 (BATOCP_INTRPT_TMOUT_7MS),7 (BATOCP_INTRPT_TMOUT_8MS)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATOCP_DELAY_TIMEOUT                     = " "0 (BATOCP_DELAY_TMOUT_1MS),1 (BATOCP_DELAY_TMOUT_2MS),2 (BATOCP_DELAY_TMOUT_3MS),3 (BATOCP_DELAY_TMOUT_4MS),4 (BATOCP_DELAY_TMOUT_5MS),5 (BATOCP_DELAY_TMOUT_6MS),6 (BATOCP_DELAY_TMOUT_7MS),7 (BATOCP_DELAY_TMOUT_8MS)"
    tree.end
    tree "SMB2CHG_BATIF_BATOCP_RESET_TMR_CFG"
      sgroup "SMB2CHG_BATIF_BATOCP_RESET_TMR_CFG (at 0x1252)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_BATOCP_RESET_TMR                      = " "0 (BATOCP_DISABLE_RESET_TMR),1 (BATOCP_ENABLE_RESET_TMR)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATOCP_RESET_TIMEOUT                     = " "0 (BATOCP_RESET_TMOUT_100MS),1 (BATOCP_RESET_TMOUT_200MS),2 (BATOCP_RESET_TMOUT_300MS),3 (BATOCP_RESET_TMOUT_400MS),4 (BATOCP_RESET_TMOUT_500MS),5 (BATOCP_RESET_TMOUT_600MS),6 (BATOCP_RESET_TMOUT_700MS),7 (BATOCP_RESET_TMOUT_800MS)"
    tree.end
    tree "SMB2CHG_BATIF_LOW_BATT_DETECT_EN_CFG"
      sgroup "SMB2CHG_BATIF_LOW_BATT_DETECT_EN_CFG (at 0x1260)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOW_BATT_DETECT_EN                       = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_LOW_BATT_THRESHOLD_CFG"
      sgroup "SMB2CHG_BATIF_LOW_BATT_THRESHOLD_CFG (at 0x1261)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOW_BATT_THRESHOLD                       = "
    tree.end
    tree "SMB2CHG_BATIF_BAT_FET_CFG"
      sgroup "SMB2CHG_BATIF_BAT_FET_CFG (at 0x1262)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_FET_CFG                              = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_BAT_MISS_SRC_CFG"
      sgroup "SMB2CHG_BATIF_BAT_MISS_SRC_CFG (at 0x1270)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISS_ALG_EN                          = " "0 (BMA_DIS),1 (BMA_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_MISS_THERM_SRC_EN                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_MISS_BATID_SRC_EN                    = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_BAT_MISS_ALG_OPTIONS_CFG"
      sgroup "SMB2CHG_BATIF_BAT_MISS_ALG_OPTIONS_CFG (at 0x1271)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISS_INPUT_PLUGIN                    = " "0 (BMA_PLUG_IN_DIS),1 (BMA_PLUG_IN_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_MISS_TMR_START_OPTION                = " "0 (BMA_TMR_STARTS_AT_2V),1 (BMA_TMR_STARTS_IMMEDIATELY)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_MISS_POLL_EN                         = " "0 (BMA_POLLER_DIS),1 (BMA_POLLER_EN)"
    tree.end
    tree "SMB2CHG_BATIF_BAT_MISS_PIN_GF_CFG"
      sgroup "SMB2CHG_BATIF_BAT_MISS_PIN_GF_CFG (at 0x1272)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_MISS_PIN_GF                          = " "0 (BMD_RMV_80US),1 (BMD_RMV_160US),2 (BMD_RMV_320US),3 (BMD_RMV_640US)"
    tree.end
    tree "SMB2CHG_BATIF_CFG_SMISC_BATID_THERM"
      sgroup "SMB2CHG_BATIF_CFG_SMISC_BATID_THERM (at 0x1273)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   CFG_SMISC_BATID_BMD                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CFG_SMISC_THERM_BMD                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CFG_SMISC_RBIAS_EXT_CTRL                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SMISC_RBIAS_BATTN_SEL                = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_BATIF_ENG_SMISC_DIETEMP"
      sgroup "SMB2CHG_BATIF_ENG_SMISC_DIETEMP (at 0x12c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ENG_SMISC_DIETEMP                        = "
    tree.end
    tree "SMB2CHG_BATIF_SEC_ACCESS"
      sgroup "SMB2CHG_BATIF_SEC_ACCESS (at 0x12d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMB2CHG_BATIF_PERPH_RESET_CTL2"
      sgroup "SMB2CHG_BATIF_PERPH_RESET_CTL2 (at 0x12d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_PERPH_RESET_CTL3"
      sgroup "SMB2CHG_BATIF_PERPH_RESET_CTL3 (at 0x12da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_PERPH_RESET_CTL4"
      sgroup "SMB2CHG_BATIF_PERPH_RESET_CTL4 (at 0x12db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_SPARE"
      sgroup "SMB2CHG_BATIF_SPARE (at 0x12df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_BATIF_INT_TEST1"
      sgroup "SMB2CHG_BATIF_INT_TEST1 (at 0x12e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_INT_TEST_VAL"
      sgroup "SMB2CHG_BATIF_INT_TEST_VAL (at 0x12e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_TERMINAL_MISSING_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_THERM_OR_ID_MISSING_VAL              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_LOW_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_OV_VAL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_OCP_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_VAL                             = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_TM_SMISC"
      sgroup "SMB2CHG_BATIF_TM_SMISC (at 0x12e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   TM_OUTPUT_DRIVING                        = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_SMISC_R_BYPASS                        = " "0, 1"
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_DPDM_PU"
      sgroup "SMB2CHG_BATIF_TR_SMISC_DPDM_PU (at 0x12f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SMISC_DPDM_PU                         = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_DPLUS_I"
      sgroup "SMB2CHG_BATIF_TR_SMISC_DPLUS_I (at 0x12f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SMISC_DPLUS_I                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_DPLUS_R"
      sgroup "SMB2CHG_BATIF_TR_SMISC_DPLUS_R (at 0x12f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SMISC_DPLUS_R                         = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_DFP_ISRC"
      sgroup "SMB2CHG_BATIF_TR_SMISC_DFP_ISRC (at 0x12f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SMISC_DFP_ISRC                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_STDBYOSC_MAIN"
      sgroup "SMB2CHG_BATIF_TR_SMISC_STDBYOSC_MAIN (at 0x12f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SMISC_STDBYOSC_MAIN                   = "
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_STDBYOSC_TEMP"
      sgroup "SMB2CHG_BATIF_TR_SMISC_STDBYOSC_TEMP (at 0x12f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SMISC_STDBYOSC_TEMP                   = "
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_RD_CC"
      sgroup "SMB2CHG_BATIF_TR_SMISC_RD_CC (at 0x12f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SMISC_RD_CC                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_FMB_2P5UA"
      sgroup "SMB2CHG_BATIF_TR_SMISC_FMB_2P5UA (at 0x12f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SMISC_FMB_2P5UA                       = "
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_CRUDE_1P8V"
      sgroup "SMB2CHG_BATIF_TR_SMISC_CRUDE_1P8V (at 0x12f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   TR_SMISC_CRUDE_1P8V                      = "
    tree.end
    tree "SMB2CHG_BATIF_TR_SMISC_DIETEMP"
      sgroup "SMB2CHG_BATIF_TR_SMISC_DIETEMP (at 0x12f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SMISC_DIETEMP                         = "
    tree.end
  tree.end
tree.end
tree "SMB2CHG_CHGR"
  tree "SMB2CHG_CHGR"
    tree "SMB2CHG_CHGR_PERPH_TYPE"
      sgroup "SMB2CHG_CHGR_PERPH_TYPE (at 0x1004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMB2CHG_CHGR_PERPH_SUBTYPE"
      sgroup "SMB2CHG_CHGR_PERPH_SUBTYPE (at 0x1005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_1"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_1 (at 0x1006)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BVR_INITIAL_RAMP                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CC_SOFT_TERMINATE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   STEP_CHARGING_STATUS                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BATTERY_CHARGER_STATUS                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_2"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_2 (at 0x1007)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_CURRENT_LIMITED                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHARGER_ERROR_STATUS_SFT_EXPIRE          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CHARGER_ERROR_STATUS_BAT_OV              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHARGER_ERROR_STATUS_BAT_TERM_MISSING    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_TEMP_STATUS_HOT_SOFT_LIMIT           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_TEMP_STATUS_COLD_SOFT_LIMIT          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_TEMP_STATUS_TOO_HOT                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BAT_TEMP_STATUS_TOO_COLD                 = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_CHG_OPTION"
      sgroup "SMB2CHG_CHGR_CHG_OPTION (at 0x1008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN                                      = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_3"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_3 (at 0x1009)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FV_POST_JEITA                            = "
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_4"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_4 (at 0x100a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHARGE_CURRENT_POST_JEITA                = "
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_5"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_5 (at 0x100b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VALID_INPUT_POWER_SOURCE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DISABLE_CHARGING                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_ZERO_CHARGE_CURRENT                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHARGING_ENABLE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TAPER                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENABLE_CHG_SENSORS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENABLE_TAPER_SENSOR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TAPER_REGION                             = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_6"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_6 (at 0x100c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GF_BATT_OV                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DROP_IN_BATTERY_VOLTAGE_REFERENCE        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   VBATT_LTET_RECHARGE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VBATT_GTET_INHIBIT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VBATT_GTET_FLOAT_VOLTAGE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATT_GT_PRE_TO_FAST                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BATT_GT_FULL_ON                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VBATT_LT_2V                              = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_7"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_7 (at 0x100d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_TRICKLE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ENABLE_PRE_CHARGING                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENABLE_FAST_CHARGING                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENABLE_FULLON_MODE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TOO_COLD_ADC                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TOO_HOT_ADC                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_SL_ADC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COLD_SL_ADC                              = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_8"
      sgroup "SMB2CHG_CHGR_BATTERY_CHARGER_STATUS_8 (at 0x100e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PRE_FAST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PRE_FULLON                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PRE_RCHG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PRE_INHIBIT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PRE_OVRV                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PRE_TERM                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_ID_BMISS_CMP                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERM_CMP                                = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_RT_STS"
      sgroup "SMB2CHG_CHGR_INT_RT_STS (at 0x1010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_RT_STS  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_RT_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_RT_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_RT_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_RT_STS                        = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_SET_TYPE"
      sgroup "SMB2CHG_CHGR_INT_SET_TYPE (at 0x1011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_TYPE    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_TYPE       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_TYPE          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_TYPE               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_TYPE                          = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_POLARITY_HIGH"
      sgroup "SMB2CHG_CHGR_INT_POLARITY_HIGH (at 0x1012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_HIGH    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_HIGH       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_HIGH          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_HIGH               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_HIGH                          = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_POLARITY_LOW"
      sgroup "SMB2CHG_CHGR_INT_POLARITY_LOW (at 0x1013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_LOW     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_LOW        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_LOW           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_LOW                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LOW                           = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_LATCHED_CLR"
      sgroup "SMB2CHG_CHGR_INT_LATCHED_CLR (at 0x1014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_LATCHED_CLR = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_LATCHED_CLR = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_LATCHED_CLR   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_EN_SET"
      sgroup "SMB2CHG_CHGR_INT_EN_SET (at 0x1015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_EN_SET  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_EN_SET     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_EN_SET        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_EN_SET             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_SET                        = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_EN_CLR"
      sgroup "SMB2CHG_CHGR_INT_EN_CLR (at 0x1016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_EN_CLR  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_EN_CLR     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_EN_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_EN_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_CLR                        = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_LATCHED_STS"
      sgroup "SMB2CHG_CHGR_INT_LATCHED_STS (at 0x1018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_LATCHED_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_LATCHED_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_LATCHED_STS   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_LATCHED_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_PENDING_STS"
      sgroup "SMB2CHG_CHGR_INT_PENDING_STS (at 0x1019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_PENDING_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_PENDING_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_PENDING_STS   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_PENDING_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_PENDING_STS                   = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_MID_SEL"
      sgroup "SMB2CHG_CHGR_INT_MID_SEL (at 0x101a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_CHGR_INT_PRIORITY"
      sgroup "SMB2CHG_CHGR_INT_PRIORITY (at 0x101b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_VBATT_V"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_VBATT_V (at 0x1040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STEP_CHG_SOC_VBATT_V                     = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_VBATT_V_UPDATE"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_VBATT_V_UPDATE (at 0x1041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEP_CHG_SOC_VBATT_V_UPDATE              = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_CHARGING_ENABLE_CMD"
      sgroup "SMB2CHG_CHGR_CHARGING_ENABLE_CMD (at 0x1042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGING_ENABLE_CMD                      = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_ALLOW_FAST_CHARGING_CMD"
      sgroup "SMB2CHG_CHGR_ALLOW_FAST_CHARGING_CMD (at 0x1043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALLOW_FAST_CHARGING_CMD                  = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_CHGR_CFG1"
      sgroup "SMB2CHG_CHGR_CHGR_CFG1 (at 0x1050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INCREASE_RCHG_TIMEOUT_CFG                = " "0 (PRE_RCHG_20MS_GF),1 (PRE_RCHG_5S_GF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOAD_BAT                                 = " "0 (LOAD_BATT_FV_COMP_DIS),1 (LOAD_BATT_FV_COMP_EN)"
    tree.end
    tree "SMB2CHG_CHGR_CHGR_CFG2"
      sgroup "SMB2CHG_CHGR_CHGR_CFG2 (at 0x1051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_EN_SRC                               = " "0 (CHG_EN_SRC_CMD),1 (CHG_EN_SRC_PIN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_EN_COMMAND                           = " "0 (CHG_EN_POL_HIGH),1 (CHG_EN_POL_LOW)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PRETOFAST_TRANSITION_CFG                 = " "0 (PRE_FAST_AUTO),1 (PRE_FAST_CMD)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_ECC                               = " "0 (BATT_OV_ENDS_CYCLE_DIS),1 (BATT_OV_ENDS_CYCLE_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   I_TERM                                   = " "0 (CURRENT_TERM_EN),1 (CURRENT_TERM_DIS)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTO_RECHG                               = " "0 (AUTO_RCHG_EN),1 (AUTO_RCHG_DIS)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_ANALOG_DROP_IN_VBATT                  = " "0 (ANALOG_DROP_IN_VBATT_DIS),1 (ANALOG_DROP_IN_VBATT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGER_INHIBIT                          = " "0 (CHG_INHIBIT_DIS),1 (CHG_INHIBIT_EN)"
    tree.end
    tree "SMB2CHG_CHGR_CHARGER_ENABLE_CFG"
      sgroup "SMB2CHG_CHGR_CHARGER_ENABLE_CFG (at 0x1052)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHG_ENB_TIMEOUT_SETTING                  = " "0 (CHG_ENB_TMR_30MS),1 (CHG_ENB_TMR_300MS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_ZERO_CFG                           = " "0 (CHG_CUR_RAMPDWN_CFG1),1 (CHG_CUR_RAMPDWN_CFG2)"
    tree.end
    tree "SMB2CHG_CHGR_CFG"
      sgroup "SMB2CHG_CHGR_CFG (at 0x1053)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_OPTION_PIN_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATN_SNS_CFG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CFG_TAPER_DIS_AFVC                       = " "0 (AFVC_ACTIVE_IN_TAPER),1 (AFVC_DISABLE_IN_TAPER)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BATFET_SHUTDOWN_CFG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VDISCHG_EN_CFG                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VCHG_EN_CFG                              = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_CHARGER_SPARE"
      sgroup "SMB2CHG_CHGR_CHARGER_SPARE (at 0x1054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   CHARGER_SPARE                            = "
    tree.end
    tree "SMB2CHG_CHGR_PRE_CHARGE_CURRENT_CFG"
      sgroup "SMB2CHG_CHGR_PRE_CHARGE_CURRENT_CFG (at 0x1060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRE_CHARGE_CURRENT_SETTING               = "
    tree.end
    tree "SMB2CHG_CHGR_FAST_CHARGE_CURRENT_CFG"
      sgroup "SMB2CHG_CHGR_FAST_CHARGE_CURRENT_CFG (at 0x1061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FAST_CHARGE_CURRENT_SETTING              = "
    tree.end
    tree "SMB2CHG_CHGR_CHARGE_CURRENT_TERMINATION_CFG"
      sgroup "SMB2CHG_CHGR_CHARGE_CURRENT_TERMINATION_CFG (at 0x1062)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ANALOG_CHARGE_CURRENT_TERMINATION_SETTING = " "0 (TERM_ANA_300MA),1 (TERM_ANA_50MA),2 (TERM_ANA_100MA),3 (TERM_ANA_150MA),4 (TERM_ANA_200MA),5 (TERM_ANA_250MA),6 (TERM_ANA_500MA),7 (TERM_ANA_600MA)"
    tree.end
    tree "SMB2CHG_CHGR_TCCC_CHARGE_CURRENT_TERMINATION_CFG"
      sgroup "SMB2CHG_CHGR_TCCC_CHARGE_CURRENT_TERMINATION_CFG (at 0x1063)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TCCC_CHARGE_CURRENT_TERMINATION_SETTING  = "
    tree.end
    tree "SMB2CHG_CHGR_CHARGE_CURRENT_SOFTSTART_SETTING_CFG"
      sgroup "SMB2CHG_CHGR_CHARGE_CURRENT_SOFTSTART_SETTING_CFG (at 0x1064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHARGE_CURRENT_SOFTSTART_SETTING         = " "0 (CHARGE_CURRENT_SOFSTART_FASTEST),1 (CHARGE_CURRENT_SOFSTART_FASTER),2 (CHARGE_CURRENT_SOFSTART_SLOWER),3 (CHARGE_CURRENT_SOFSTART_SLOWEST)"
    tree.end
    tree "SMB2CHG_CHGR_FLOAT_VOLTAGE_CFG"
      sgroup "SMB2CHG_CHGR_FLOAT_VOLTAGE_CFG (at 0x1070)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FLOAT_VOLTAGE_SETTING                    = "
    tree.end
    tree "SMB2CHG_CHGR_AUTO_FLOAT_VOLTAGE_COMPENSATION_CFG"
      sgroup "SMB2CHG_CHGR_AUTO_FLOAT_VOLTAGE_COMPENSATION_CFG (at 0x1071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   AUTO_FLOAT_VOLTAGE_COMPENSATION          = " "0 (AUTO_FV_DISABLED),1 (AUTO_FV_25MV),2 (AUTO_FV_50MV),3 (AUTO_FV_75MV),4 (AUTO_FV_100MV),5 (AUTO_FV_125MV),6 (AUTO_FV_150MV),7 (AUTO_FV_175MV)"
    tree.end
    tree "SMB2CHG_CHGR_CHARGE_INHIBIT_THRESHOLD_CFG"
      sgroup "SMB2CHG_CHGR_CHARGE_INHIBIT_THRESHOLD_CFG (at 0x1072)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHARGE_INHIBIT_THRESHOLD                 = " "0 (INHIBIT_50MV),1 (INHIBIT_100MV),2 (INHIBIT_200MV),3 (INHIBIT_300MV)"
    tree.end
    tree "SMB2CHG_CHGR_RECHARGE_THRESHOLD_CFG"
      sgroup "SMB2CHG_CHGR_RECHARGE_THRESHOLD_CFG (at 0x1073)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RECHARGE_THRESHOLD                       = " "0 (INHIBIT_50MV),1 (INHIBIT_100MV),2 (INHIBIT_200MV),3 (INHIBIT_300MV)"
    tree.end
    tree "SMB2CHG_CHGR_PRE_TO_FAST_CHARGE_THRESHOLD_CFG"
      sgroup "SMB2CHG_CHGR_PRE_TO_FAST_CHARGE_THRESHOLD_CFG (at 0x1074)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRE_TO_FAST_CHARGE_THRESHOLD             = " "0 (P2F_2P4),1 (P2F_2P6),2 (P2F_2P8),3 (P2F_3P0)"
    tree.end
    tree "SMB2CHG_CHGR_FVC_CHARGE_INHIBIT_THRESHOLD_CFG"
      sgroup "SMB2CHG_CHGR_FVC_CHARGE_INHIBIT_THRESHOLD_CFG (at 0x1080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FVC_CHARGE_INHIBIT_THRESHOLD             = "
    tree.end
    tree "SMB2CHG_CHGR_FVC_RECHARGE_THRESHOLD_CFG"
      sgroup "SMB2CHG_CHGR_FVC_RECHARGE_THRESHOLD_CFG (at 0x1081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FVC_RECHARGE_THRESHOLD                   = "
    tree.end
    tree "SMB2CHG_CHGR_FVC_PRE_TO_FAST_CHARGE_THRESHOLD_CFG"
      sgroup "SMB2CHG_CHGR_FVC_PRE_TO_FAST_CHARGE_THRESHOLD_CFG (at 0x1082)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FVC_PRE_TO_FAST_CHARGE_THRESHOLD         = "
    tree.end
    tree "SMB2CHG_CHGR_FVC_FULL_ON_THRESHOLD_CFG"
      sgroup "SMB2CHG_CHGR_FVC_FULL_ON_THRESHOLD_CFG (at 0x1083)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   FVC_FULL_ON_THRESHOLD                    = "
    tree.end
    tree "SMB2CHG_CHGR_FVC_CC_MODE_GLITCH_FILTER_SEL_CFG"
      sgroup "SMB2CHG_CHGR_FVC_CC_MODE_GLITCH_FILTER_SEL_CFG (at 0x1084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FVC_CC_MODE_GLITCH_FILTER_SEL            = " "0 (FVC_CC_MODE_GLITCH_FILTER_SHORTEST),1 (FVC_CC_MODE_GLITCH_FILTER_SHORTER),2 (FVC_CC_MODE_GLITCH_FILTER_LONGER),3 (FVC_CC_MODE_GLITCH_FILTER_LONGEST)"
    tree.end
    tree "SMB2CHG_CHGR_FVC_TERMINATION_GLITCH_FILTER_SEL_CFG"
      sgroup "SMB2CHG_CHGR_FVC_TERMINATION_GLITCH_FILTER_SEL_CFG (at 0x1085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FVC_TERMINATION_GLITCH_FILTER_SEL        = " "0 (FVC_TERMINATION_GLITCH_FILTER_SHORTEST),1 (FVC_TERMINATION_GLITCH_FILTER_SHORTER),2 (FVC_TERMINATION_GLITCH_FILTER_LONGER),3 (FVC_TERMINATION_GLITCH_FILTER_LONGEST)"
    tree.end
    tree "SMB2CHG_CHGR_JEITA_EN_CFG"
      sgroup "SMB2CHG_CHGR_JEITA_EN_CFG (at 0x1090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   JEITA_EN_HARDLIMIT                       = " "0 (JEITA_TEMP_HARD_LIMIT_DIS),1 (JEITA_TEMP_HARD_LIMIT_EN)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   JEITA_EN_HOT_SL_FCV                      = " "0 (JEITA_HOT_SOFT_LIMIT_FV_COMP_DIS),1 (JEITA_HOT_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   JEITA_EN_COLD_SL_FCV                     = " "0 (JEITA_COLD_SOFT_LIMIT_FV_COMP_DIS),1 (JEITA_COLD_SOFT_LIMIT_FV_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   JEITA_EN_HOT_SL_CCC                      = " "0 (JEITA_HOT_SOFT_LIMIT_CC_COMP_DIS),1 (JEITA_HOT_SOFT_LIMIT_CC_COMP_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   JEITA_EN_COLD_SL_CCC                     = " "0 (JEITA_COLD_SOFT_LIMIT_CC_COMP_DIS),1 (JEITA_COLD_SOFT_LIMIT_CC_COMP_EN)"
    tree.end
    tree "SMB2CHG_CHGR_JEITA_FVCOMP_CFG"
      sgroup "SMB2CHG_CHGR_JEITA_FVCOMP_CFG (at 0x1091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   JEITA_FVCOMP                             = "
    tree.end
    tree "SMB2CHG_CHGR_JEITA_CCCOMP_CFG"
      sgroup "SMB2CHG_CHGR_JEITA_CCCOMP_CFG (at 0x1092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   JEITA_CCCOMP                             = "
    tree.end
    tree "SMB2CHG_CHGR_SAFETY_TIMER_ENABLE_CFG"
      sgroup "SMB2CHG_CHGR_SAFETY_TIMER_ENABLE_CFG (at 0x10a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PRE_CHARGE_SAFETY_TIMER_EN               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FAST_CHARGE_SAFETY_TIMER_EN              = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_PRE_CHARGE_SAFETY_TIMER_CFG"
      sgroup "SMB2CHG_CHGR_PRE_CHARGE_SAFETY_TIMER_CFG (at 0x10a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRECHARGE_SAFETY_TIMER                   = " "0 (PC_TMOUT_24MIN),1 (PC_TMOUT_48MIN),2 (PC_TMOUT_96MIN),3 (PC_TMOUT_192MIN)"
    tree.end
    tree "SMB2CHG_CHGR_FAST_CHARGE_SAFETY_TIMER_CFG"
      sgroup "SMB2CHG_CHGR_FAST_CHARGE_SAFETY_TIMER_CFG (at 0x10a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FAST_CHARGE_SAFETY_TIMER                 = " "0 (FC_TMOUT_192MIN),1 (FC_TMOUT_384MIN),2 (FC_TMOUT_768MIN),3 (FC_TMOUT_1536MIN)"
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_MODE_CFG"
      sgroup "SMB2CHG_CHGR_STEP_CHG_MODE_CFG (at 0x10b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_FAIL_OPTION            = " "0 (STEP_CHARGING_STANDARD_MODE),1 (STEP_CHARGING_AUTONOMOUS_MODE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_MODE_SELECT                = " "0 (STEP_CHARGING_STANDARD_MODE),1 (STEP_CHARGING_AUTONOMOUS_MODE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STEP_CHARGING_SOURCE_SELECT              = " "0 (STEP_CHARGING_CONTROL_FROM_SOC),1 (STEP_CHARGING_CONTROL_FROM_VBATT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEP_CHARGING_ENABLE                     = " "0 (STEP_CHARGING_DISABLED),1 (STEP_CHARGING_ENABLED)"
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_CFG"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT_CFG (at 0x10b1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_CHG_SOC_OR_BATT_V_UPDATE_REQUEST_TIMEOUT = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_CFG"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT_CFG (at 0x10b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   STEP_CHG_SOC_OR_BATT_V_UPDATE_FAIL_TIMEOUT = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD1"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD1 (at 0x10b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD1        = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD2"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD2 (at 0x10b4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD2        = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD3"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD3 (at 0x10b5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD3        = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD4"
      sgroup "SMB2CHG_CHGR_STEP_CHG_SOC_OR_BATT_V_THRESHOLD4 (at 0x10b6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   STEP_CHG_SOC_OR_BATT_V_THRESHOLD4        = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA1"
      sgroup "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA1 (at 0x10b7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA1                  = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA2"
      sgroup "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA2 (at 0x10b8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA2                  = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA3"
      sgroup "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA3 (at 0x10b9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010b90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10b90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA3                  = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA4"
      sgroup "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA4 (at 0x10ba)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ba0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ba0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA4                  = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA5"
      sgroup "SMB2CHG_CHGR_STEP_CHG_CURRENT_DELTA5 (at 0x10bb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_CURRENT_DELTA5                  = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_FV_DELTA1"
      sgroup "SMB2CHG_CHGR_STEP_CHG_FV_DELTA1 (at 0x10bc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA1                       = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_FV_DELTA2"
      sgroup "SMB2CHG_CHGR_STEP_CHG_FV_DELTA2 (at 0x10bd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA2                       = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_FV_DELTA3"
      sgroup "SMB2CHG_CHGR_STEP_CHG_FV_DELTA3 (at 0x10be)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010be0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10be0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA3                       = "
    tree.end
    tree "SMB2CHG_CHGR_STEP_CHG_FV_DELTA4"
      sgroup "SMB2CHG_CHGR_STEP_CHG_FV_DELTA4 (at 0x10bf)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010bf0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10bf0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   STEP_CHG_FV_DELTA4                       = "
    tree.end
    tree "SMB2CHG_CHGR_ENG_CHARGING_CFG"
      sgroup "SMB2CHG_CHGR_ENG_CHARGING_CFG (at 0x10c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USE_ANALOG_CHARGING_LEVELS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FVC_ALG_ENABLE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CCSOFTSTART_ALG_ENABLE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TERMINATION_ALG_ENABLE                   = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_ENG_SBQ_CFG1"
      sgroup "SMB2CHG_CHGR_ENG_SBQ_CFG1 (at 0x10c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ENG_CHARGE_CURRENT_SENSE_OPTION          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_SBQ_SYSTHR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENG_SBQ_NEW_VREF_ILIMIT                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENG_SBQ_IDAC_SCALE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_SBQ_DIS_GATE_CLAMP                   = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_ENG_SBQ_RESERVE1"
      sgroup "SMB2CHG_CHGR_ENG_SBQ_RESERVE1 (at 0x10c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ENG_SBQ_RESERVE1                         = "
    tree.end
    tree "SMB2CHG_CHGR_ENG_SBQ_RESERVE2"
      sgroup "SMB2CHG_CHGR_ENG_SBQ_RESERVE2 (at 0x10c3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010c30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10c30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ENG_SBQ_RESERVE2                         = "
    tree.end
    tree "SMB2CHG_CHGR_SEC_ACCESS"
      sgroup "SMB2CHG_CHGR_SEC_ACCESS (at 0x10d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMB2CHG_CHGR_PERPH_RESET_CTL2"
      sgroup "SMB2CHG_CHGR_PERPH_RESET_CTL2 (at 0x10d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_PERPH_RESET_CTL3"
      sgroup "SMB2CHG_CHGR_PERPH_RESET_CTL3 (at 0x10da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_PERPH_RESET_CTL4"
      sgroup "SMB2CHG_CHGR_PERPH_RESET_CTL4 (at 0x10db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_SPARE"
      sgroup "SMB2CHG_CHGR_SPARE (at 0x10df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_CHGR_INT_TEST1"
      sgroup "SMB2CHG_CHGR_INT_TEST1 (at 0x10e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_INT_TEST_VAL"
      sgroup "SMB2CHG_CHGR_INT_TEST_VAL (at 0x10e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STEP_CHARGING_SOC_UPDATE_REQUEST_VAL     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STEP_CHARGING_SOC_UPDATE_FAIL_VAL        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STEP_CHARGING_STATE_CHANGE_VAL           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHARGING_STATE_CHANGE_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_VAL                           = " "0, 1"
    tree.end
    tree "SMB2CHG_CHGR_TM_SBQ_RESERVE1"
      sgroup "SMB2CHG_CHGR_TM_SBQ_RESERVE1 (at 0x10e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_SBQ_RESERVE1                          = "
    tree.end
    tree "SMB2CHG_CHGR_TM_SBQ_RESERVE2"
      sgroup "SMB2CHG_CHGR_TM_SBQ_RESERVE2 (at 0x10e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_SBQ_RESERVE2                          = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FLT_OFFSET"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FLT_OFFSET (at 0x10f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SBQ_FLT_OFFSET                        = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FLT_SCALE"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FLT_SCALE (at 0x10f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SBQ_FLT_SCALE                         = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_LINEAR_8X_IOUTCS_CHGOS"
      sgroup "SMB2CHG_CHGR_TR_SBQ_LINEAR_8X_IOUTCS_CHGOS (at 0x10f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_LINEAR_8X_IOUTCS_CHGOS            = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_LINEAR_1X_IOUTCS_CHGOS"
      sgroup "SMB2CHG_CHGR_TR_SBQ_LINEAR_1X_IOUTCS_CHGOS (at 0x10f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_LINEAR_1X_IOUTCS_CHGOS            = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FULLON_8X_IOUTCS_CHGOS"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FULLON_8X_IOUTCS_CHGOS (at 0x10f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_FULLON_8X_IOUTCS_CHGOS            = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FULLON_1X_IOUTCS_CHGOS"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FULLON_1X_IOUTCS_CHGOS (at 0x10f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_FULLON_1X_IOUTCS_CHGOS            = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_LINEAR_8X_IOUT_OFFSET"
      sgroup "SMB2CHG_CHGR_TR_SBQ_LINEAR_8X_IOUT_OFFSET (at 0x10f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_LINEAR_8X_IOUT_OFFSET             = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_LINEAR_1X_IOUT_OFFSET"
      sgroup "SMB2CHG_CHGR_TR_SBQ_LINEAR_1X_IOUT_OFFSET (at 0x10f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_LINEAR_1X_IOUT_OFFSET             = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FULLON_8X_IOUT_OFFSET"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FULLON_8X_IOUT_OFFSET (at 0x10f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_FULLON_8X_IOUT_OFFSET             = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FULLON_1X_IOUT_OFFSET"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FULLON_1X_IOUT_OFFSET (at 0x10f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_FULLON_1X_IOUT_OFFSET             = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_LINEAR_8X_IOUT_GAIN"
      sgroup "SMB2CHG_CHGR_TR_SBQ_LINEAR_8X_IOUT_GAIN (at 0x10fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_LINEAR_8X_IOUT_GAIN               = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_LINEAR_1X_IOUT_GAIN"
      sgroup "SMB2CHG_CHGR_TR_SBQ_LINEAR_1X_IOUT_GAIN (at 0x10fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_LINEAR_1X_IOUT_GAIN               = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FULLON_8X_IOUT_GAIN"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FULLON_8X_IOUT_GAIN (at 0x10fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_FULLON_8X_IOUT_GAIN               = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_FULLON_1X_IOUT_GAIN"
      sgroup "SMB2CHG_CHGR_TR_SBQ_FULLON_1X_IOUT_GAIN (at 0x10fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_FULLON_1X_IOUT_GAIN               = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_TERMINATION"
      sgroup "SMB2CHG_CHGR_TR_SBQ_TERMINATION (at 0x10fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_TERMINATION                       = "
    tree.end
    tree "SMB2CHG_CHGR_TR_SBQ_BATLOW"
      sgroup "SMB2CHG_CHGR_TR_SBQ_BATLOW (at 0x10ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SBQ_BATLOW                            = "
    tree.end
  tree.end
tree.end
tree "SMB2CHG_DC"
  tree "SMB2CHG_DC"
    tree "SMB2CHG_DC_PERPH_TYPE"
      sgroup "SMB2CHG_DC_PERPH_TYPE (at 0x1404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMB2CHG_DC_PERPH_SUBTYPE"
      sgroup "SMB2CHG_DC_PERPH_SUBTYPE (at 0x1405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMB2CHG_DC_DCIN_INPUT_STATUS"
      sgroup "SMB2CHG_DC_DCIN_INPUT_STATUS (at 0x1406)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DCIN_INPUT_STATUS_7                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_INPUT_STATUS_6                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_12V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_9V_TO_12V                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_9V                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_5V_TO_12V                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_5V_TO_9V                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_5V                                  = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_WIPWR_STATUS"
      sgroup "SMB2CHG_DC_WIPWR_STATUS (at 0x1407)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WIPWR_STATUS_7                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WIPWR_STATUS_6                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WIPWR_STATUS_5                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_WIPWR_OV_DG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DIV2_EN_DG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SHUTDOWN_N_LATCH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHG_OK_PIN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WIPWR_CHARGING_ENABLED                   = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_RT_STS"
      sgroup "SMB2CHG_DC_INT_RT_STS (at 0x1410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_RT_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_RT_STS                     = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_SET_TYPE"
      sgroup "SMB2CHG_DC_INT_SET_TYPE (at 0x1411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_TYPE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_TYPE                       = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_POLARITY_HIGH"
      sgroup "SMB2CHG_DC_INT_POLARITY_HIGH (at 0x1412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_HIGH                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_HIGH                       = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_POLARITY_LOW"
      sgroup "SMB2CHG_DC_INT_POLARITY_LOW (at 0x1413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_LOW                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_LOW                        = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_LATCHED_CLR"
      sgroup "SMB2CHG_DC_INT_LATCHED_CLR (at 0x1414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_LATCHED_CLR                = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_EN_SET"
      sgroup "SMB2CHG_DC_INT_EN_SET (at 0x1415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_EN_SET                     = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_EN_CLR"
      sgroup "SMB2CHG_DC_INT_EN_CLR (at 0x1416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_EN_CLR                     = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_LATCHED_STS"
      sgroup "SMB2CHG_DC_INT_LATCHED_STS (at 0x1418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_LATCHED_STS                = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_PENDING_STS"
      sgroup "SMB2CHG_DC_INT_PENDING_STS (at 0x1419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_PENDING_STS                = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_MID_SEL"
      sgroup "SMB2CHG_DC_INT_MID_SEL (at 0x141a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_DC_INT_PRIORITY"
      sgroup "SMB2CHG_DC_INT_PRIORITY (at 0x141b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_CMD_IL"
      sgroup "SMB2CHG_DC_CMD_IL (at 0x1440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIRELESS_CHG_DIS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SHDN_N_CLEAR_CMD                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SHDN_N_SET_CMD                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_SUSPEND                             = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_DC_SPARE"
      sgroup "SMB2CHG_DC_DC_SPARE (at 0x1458)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DC_SPARE                                 = "
    tree.end
    tree "SMB2CHG_DC_DCIN_ADAPTER_ALLOW_CFG"
      sgroup "SMB2CHG_DC_DCIN_ADAPTER_ALLOW_CFG (at 0x1460)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DCIN_ADAPTER_ALLOW                       = "
    tree.end
    tree "SMB2CHG_DC_DCIN_LOAD_CFG"
      sgroup "SMB2CHG_DC_DCIN_LOAD_CFG (at 0x1465)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_OV_CH_LOAD_OPTION                   = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_DCIN_CURRENT_LIMIT_CFG"
      sgroup "SMB2CHG_DC_DCIN_CURRENT_LIMIT_CFG (at 0x1470)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DCIN_CURRENT_LIMIT                       = "
    tree.end
    tree "SMB2CHG_DC_DCIN_AICL_OPTIONS_CFG"
      sgroup "SMB2CHG_DC_DCIN_AICL_OPTIONS_CFG (at 0x1480)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SUSPEND_ON_COLLAPSE_DCIN                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_AICL_HDC_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_AICL_START_AT_MAX                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_AICL_RERUN_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_AICL_ADC_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_AICL_EN                             = " "0 (DCIN_AICL_DISABLED),1 (DCIN_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_HV_COLLAPSE_RESPONSE                = " "0 (DCIN_COLLAPSE_HV_FET_ON),1 (DCIN_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_LV_COLLAPSE_RESPONSE                = " "0 (DCIN_COLLAPSE_LV_FET_ON),1 (DCIN_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SMB2CHG_DC_DCIN_AICL_REF_SEL_CFG"
      sgroup "SMB2CHG_DC_DCIN_AICL_REF_SEL_CFG (at 0x1481)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DCIN_AICL_CONT_TRIP                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_AICL_5V_TRIP                        = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_DCIN_ICL_START_CFG"
      sgroup "SMB2CHG_DC_DCIN_ICL_START_CFG (at 0x1482)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_ICL_START_CFG                       = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_DIV2_EN_GF_TIME_CFG"
      sgroup "SMB2CHG_DC_DIV2_EN_GF_TIME_CFG (at 0x1490)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DIV2_EN_GF_TIME_CFG                      = " "0 (DIV2_DG_0US),1 (DIV2_DG_150US),2 (DIV2_DG_250US),3 (DIV2_DG_500US)"
    tree.end
    tree "SMB2CHG_DC_WIPWR_IRQ_TMR_CFG"
      sgroup "SMB2CHG_DC_WIPWR_IRQ_TMR_CFG (at 0x1491)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   WIPWR_IRQ_TMR                            = " "0 (WIPWR_IRQ_TMR_1P3S),1 (WIPWR_IRQ_TMR_1P95S),2 (WIPWR_IRQ_TMR_2P6S),3 (WIPWR_IRQ_TMR_3P25S),4 (WIPWR_IRQ_TMR_3P9S),5 (WIPWR_IRQ_TMR_4P55S),6 (WIPWR_IRQ_TMR_5P2S),7 (WIPWR_IRQ_TMR_5P85S)"
    tree.end
    tree "SMB2CHG_DC_ZIN_ICL_PT"
      sgroup "SMB2CHG_DC_ZIN_ICL_PT (at 0x1492)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_PT                               = "
    tree.end
    tree "SMB2CHG_DC_ZIN_ICL_LV"
      sgroup "SMB2CHG_DC_ZIN_ICL_LV (at 0x1493)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_LV                               = "
    tree.end
    tree "SMB2CHG_DC_ZIN_ICL_HV"
      sgroup "SMB2CHG_DC_ZIN_ICL_HV (at 0x1494)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ZIN_ICL_HV                               = "
    tree.end
    tree "SMB2CHG_DC_WI_PWR_OPTIONS"
      sgroup "SMB2CHG_DC_WI_PWR_OPTIONS (at 0x1495)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_OK                                   = " "0 (CHG_OK_DIS),1 (CHG_OK_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WIPWR_UVLO_IRQ_OPT                       = " "0 (CHG_OK_DEPENDENT),1 (CHG_OK_INDEPENDENT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BUCK_HOLDOFF_ENABLE                      = " "0 (WIPWR_BUCK_HOLDOFF_DIS),1 (WIPWR_BUCK_HOLDOFF_EN)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CHG_OK_HW_SW_SELECT                      = " "0 (CHG_OK_SW),1 (CHG_OK_HW)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WIPWR_RST_ENABLE                         = " "0 (WIPWR_RST_DIS),1 (WIPWR_RST_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_WIPWR_IRQ_SELECT                    = " "0 (DCIN_IRQ_SEL),1 (WIPWR_IRQ_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_SWITCH_ENABLE                       = " "0 (WIPWR_AICL_SWITCH_DIS),1 (WIPWR_AICL_SWITCH_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ZIN_ICL_ENABLE                           = " "0 (ICL_CHARGER_REGS),1 (ICL_WIPWR_REGS)"
    tree.end
    tree "SMB2CHG_DC_ENG_SREFGEN_CFG1"
      sgroup "SMB2CHG_DC_ENG_SREFGEN_CFG1 (at 0x14c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ENG_SREFGEN_CFG1                         = "
    tree.end
    tree "SMB2CHG_DC_ENG_SREFGEN_CFG2"
      sgroup "SMB2CHG_DC_ENG_SREFGEN_CFG2 (at 0x14c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ENG_SREFGEN_CFG2                         = "
    tree.end
    tree "SMB2CHG_DC_SEC_ACCESS"
      sgroup "SMB2CHG_DC_SEC_ACCESS (at 0x14d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMB2CHG_DC_PERPH_RESET_CTL2"
      sgroup "SMB2CHG_DC_PERPH_RESET_CTL2 (at 0x14d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_PERPH_RESET_CTL3"
      sgroup "SMB2CHG_DC_PERPH_RESET_CTL3 (at 0x14da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_PERPH_RESET_CTL4"
      sgroup "SMB2CHG_DC_PERPH_RESET_CTL4 (at 0x14db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_SPARE"
      sgroup "SMB2CHG_DC_SPARE (at 0x14df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_DC_INT_TEST1"
      sgroup "SMB2CHG_DC_INT_TEST1 (at 0x14e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_INT_TEST_VAL"
      sgroup "SMB2CHG_DC_INT_TEST_VAL (at 0x14e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DCIN_ICL_CHANGE_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DIV2_EN_DG_VAL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_PLUGIN_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_OV_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_UV_VAL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_LT_3P6V_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_COLLAPSE_VAL                        = " "0, 1"
    tree.end
    tree "SMB2CHG_DC_TM_SREFGEN"
      sgroup "SMB2CHG_DC_TM_SREFGEN (at 0x14e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TM_SREFGEN                               = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_BGTC"
      sgroup "SMB2CHG_DC_TR_SREFGEN_BGTC (at 0x14f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SREFGEN_BGTC                          = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_REF_FINE_ADJ"
      sgroup "SMB2CHG_DC_TR_SREFGEN_REF_FINE_ADJ (at 0x14f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SREFGEN_REF_FINE_ADJ                  = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_VPTAT"
      sgroup "SMB2CHG_DC_TR_SREFGEN_VPTAT (at 0x14f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_SREFGEN_VPTAT                         = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_VTEMP"
      sgroup "SMB2CHG_DC_TR_SREFGEN_VTEMP (at 0x14f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_SREFGEN_VTEMP                         = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_IZTC"
      sgroup "SMB2CHG_DC_TR_SREFGEN_IZTC (at 0x14f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_SREFGEN_IZTC                          = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_V1V_OFF1"
      sgroup "SMB2CHG_DC_TR_SREFGEN_V1V_OFF1 (at 0x14f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SREFGEN_V1V_OFF1                      = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_V1V_OFF2"
      sgroup "SMB2CHG_DC_TR_SREFGEN_V1V_OFF2 (at 0x14f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SREFGEN_V1V_OFF2                      = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_SPARE1"
      sgroup "SMB2CHG_DC_TR_SREFGEN_SPARE1 (at 0x14f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_SREFGEN_SPARE1                        = "
    tree.end
    tree "SMB2CHG_DC_TR_SREFGEN_SPARE2"
      sgroup "SMB2CHG_DC_TR_SREFGEN_SPARE2 (at 0x14f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_SREFGEN_SPARE2                        = "
    tree.end
  tree.end
tree.end
tree "SMB2CHG_MISC"
  tree "SMB2CHG_MISC"
    tree "SMB2CHG_MISC_REVISION1"
      sgroup "SMB2CHG_MISC_REVISION1 (at 0x1600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SMB2CHG_MISC_REVISION2"
      sgroup "SMB2CHG_MISC_REVISION2 (at 0x1601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SMB2CHG_MISC_REVISION3"
      sgroup "SMB2CHG_MISC_REVISION3 (at 0x1602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SMB2CHG_MISC_REVISION4"
      sgroup "SMB2CHG_MISC_REVISION4 (at 0x1603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SMB2CHG_MISC_PERPH_TYPE"
      sgroup "SMB2CHG_MISC_PERPH_TYPE (at 0x1604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMB2CHG_MISC_PERPH_SUBTYPE"
      sgroup "SMB2CHG_MISC_PERPH_SUBTYPE (at 0x1605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMB2CHG_MISC_TEMP_RANGE_STATUS"
      sgroup "SMB2CHG_MISC_TEMP_RANGE_STATUS (at 0x1606)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_RANGE_STATUS_7                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMP_RANGE_STATUS_6                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TLIM                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ALERT_LEVEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TEMP_ABOVE_RANGE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TEMP_WITHIN_RANGE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_BELOW_RANGE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERMREG_DISABLED                        = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_ICL_STATUS"
      sgroup "SMB2CHG_MISC_ICL_STATUS (at 0x1607)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   INPUT_CURRENT_LIMIT                      = "
    tree.end
    tree "SMB2CHG_MISC_ADAPTER_5V_ICL_STATUS"
      sgroup "SMB2CHG_MISC_ADAPTER_5V_ICL_STATUS (at 0x1608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADAPTER_5V_ICL                           = "
    tree.end
    tree "SMB2CHG_MISC_ADAPTER_9V_ICL_STATUS"
      sgroup "SMB2CHG_MISC_ADAPTER_9V_ICL_STATUS (at 0x1609)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADAPTER_9V_ICL                           = "
    tree.end
    tree "SMB2CHG_MISC_AICL_STATUS"
      sgroup "SMB2CHG_MISC_AICL_STATUS (at 0x160a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80160a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x160a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AICL_STATUS_7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_ILIMIT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HIGHEST_DC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_CH_COLLAPSE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_CH_COLLAPSE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ICL_IMIN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_FAIL                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AICL_DONE                                = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_POWER_PATH_STATUS"
      sgroup "SMB2CHG_MISC_POWER_PATH_STATUS (at 0x160b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80160b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x160b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_SS_DONE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_SUSPEND                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCIN_SUSPEND                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USE_USBIN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USE_DCIN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   POWER_PATH                               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VALID_INPUT_POWER_SOURCE                 = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_WDOG_STATUS"
      sgroup "SMB2CHG_MISC_WDOG_STATUS (at 0x160c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80160c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x160c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WDOG_STATUS_7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WDOG_STATUS_6                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WDOG_STATUS_5                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WDOG_STATUS_4                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   WDOG_STATUS_3                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_STATUS_2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_STATUS_1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BARK_BITE_STATUS                         = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_RT_STS"
      sgroup "SMB2CHG_MISC_INT_RT_STS (at 0x1610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_RT_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_RT_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_RT_STS                        = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_SET_TYPE"
      sgroup "SMB2CHG_MISC_INT_SET_TYPE (at 0x1611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_TYPE                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_TYPE                          = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_POLARITY_HIGH"
      sgroup "SMB2CHG_MISC_INT_POLARITY_HIGH (at 0x1612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_HIGH                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_HIGH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_HIGH                          = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_POLARITY_LOW"
      sgroup "SMB2CHG_MISC_INT_POLARITY_LOW (at 0x1613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_LOW                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_LOW               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_LOW                           = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_LATCHED_CLR"
      sgroup "SMB2CHG_MISC_INT_LATCHED_CLR (at 0x1614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_LATCHED_CLR       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_EN_SET"
      sgroup "SMB2CHG_MISC_INT_EN_SET (at 0x1615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_EN_SET                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_EN_SET            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_EN_SET                        = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_EN_CLR"
      sgroup "SMB2CHG_MISC_INT_EN_CLR (at 0x1616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_EN_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_EN_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_EN_CLR                        = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_LATCHED_STS"
      sgroup "SMB2CHG_MISC_INT_LATCHED_STS (at 0x1618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_LATCHED_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_LATCHED_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_PENDING_STS"
      sgroup "SMB2CHG_MISC_INT_PENDING_STS (at 0x1619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_OK_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_PENDING_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_PENDING_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_PENDING_STS                   = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_MID_SEL"
      sgroup "SMB2CHG_MISC_INT_MID_SEL (at 0x161a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_INT_PRIORITY"
      sgroup "SMB2CHG_MISC_INT_PRIORITY (at 0x161b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_WDOG_RST"
      sgroup "SMB2CHG_MISC_WDOG_RST (at 0x1640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_RST                                 = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_AFP_MODE"
      sgroup "SMB2CHG_MISC_AFP_MODE (at 0x1641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AFP_MODE_EN                              = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_GSM_PA_ON_ADJ_EN"
      sgroup "SMB2CHG_MISC_GSM_PA_ON_ADJ_EN (at 0x1642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GSM_PA_ON_ADJ_EN                         = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_BARK_BITE_WDOG_PET"
      sgroup "SMB2CHG_MISC_BARK_BITE_WDOG_PET (at 0x1643)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   BARK_BITE_WDOG_PET                       = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_PHYON_CMD"
      sgroup "SMB2CHG_MISC_PHYON_CMD (at 0x1644)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHYON_CMD                                = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_CMD_RBIAS_EN"
      sgroup "SMB2CHG_MISC_CMD_RBIAS_EN (at 0x1645)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CMD_RBIAS_EN                             = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_DUAL_PHASE"
      sgroup "SMB2CHG_MISC_DUAL_PHASE (at 0x1646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ALLOW_DUAL_PHASE_SWITCHER                = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_WD_CFG"
      sgroup "SMB2CHG_MISC_WD_CFG (at 0x1651)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WATCHDOG_TRIGGER_AFP_EN                  = " "0 (AFP_WDOG_DIS),1 (AFP_WDOG_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BARK_WDOG_INT_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BITE_WDOG_INT_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SFT_AFTER_WDOG_IRQ                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_IRQ_SFT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_OPTION                              = " "0 (WDOG_AFTER_ACK),1 (WDOG_ALWAYS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_TIMER_EN                            = " "0 (WDOG_DIS),1 (WDOG_EN)"
    tree.end
    tree "SMB2CHG_MISC_MISC_CFG"
      sgroup "SMB2CHG_MISC_MISC_CFG (at 0x1652)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GSM_PA_ON_ADJ_SEL                        = " "0 (PA_ON_DIS),1 (PA_ON_EN)"
    tree.end
    tree "SMB2CHG_MISC_SNARL_BARK_BITE_WD_CFG"
      sgroup "SMB2CHG_MISC_SNARL_BARK_BITE_WD_CFG (at 0x1653)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BITE_WDOG_DISABLE_CHARGING_CFG           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   SNARL_WDOG_TIMEOUT                       = " "0 (SNARL_WDOG_TMOUT_62P5MS),1 (SNARL_WDOG_TMOUT_125MS),2 (SNARL_WDOG_TMOUT_250MS),3 (SNARL_WDOG_TMOUT_500MS),4 (SNARL_WDOG_TMOUT_1S),5 (SNARL_WDOG_TMOUT_2S),6 (SNARL_WDOG_TMOUT_4S),7 (SNARL_WDOG_TMOUT_8S)"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BARK_WDOG_TIMEOUT                        = " "0 (BARK_WDOG_TMOUT_16S),1 (BARK_WDOG_TMOUT_32S),2 (BARK_WDOG_TMOUT_64S),3 (BARK_WDOG_TMOUT_128S)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BITE_WDOG_TIMEOUT                        = " "0 (BITE_WDOG_TMOUT_1S),1 (BITE_WDOG_TMOUT_2S),2 (BITE_WDOG_TMOUT_4S),3 (BITE_WDOG_TMOUT_8S)"
    tree.end
    tree "SMB2CHG_MISC_PHYON_CFG"
      sgroup "SMB2CHG_MISC_PHYON_CFG (at 0x1654)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBPHYON_PUSHPULL_CFG                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PHYON_SW_SEL                             = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_CHGR_TRIM_OPTIONS_7_0"
      sgroup "SMB2CHG_MISC_CHGR_TRIM_OPTIONS_7_0 (at 0x1655)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TLIM_DIS_TBIT                            = " "0 (TLIM_EN),1 (TLIM_DIS)"
    tree.end
    tree "SMB2CHG_MISC_CH_OV_OPTION_CFG"
      sgroup "SMB2CHG_MISC_CH_OV_OPTION_CFG (at 0x1656)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OV_OPTION_TBIT                           = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_AICL_CFG"
      sgroup "SMB2CHG_MISC_AICL_CFG (at 0x1660)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TREG_ALLOW_DECREASE                      = " "0 (AICL_RERUN_DIS),1 (AICL_RERUN_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AICL_HIGH_DC_INC                         = " "0 (AICL_RERUN_DIS),1 (AICL_RERUN_EN)"
    tree.end
    tree "SMB2CHG_MISC_AICL_RERUN_TIME_CFG"
      sgroup "SMB2CHG_MISC_AICL_RERUN_TIME_CFG (at 0x1661)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AICL_RERUN_TIME                          = " "0 (AICL_RERUN_TIME_0P2S),1 (AICL_RERUN_TIME_0P4S),2 (AICL_RERUN_TIME_0P8S),3 (AICL_RERUN_TIME_1P6S)"
    tree.end
    tree "SMB2CHG_MISC_AICL_RERUN_TEMP_TIME_CFG"
      sgroup "SMB2CHG_MISC_AICL_RERUN_TEMP_TIME_CFG (at 0x1662)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AICL_RERUN_TEMP_TIME                     = " "0 (AICL_RERUN_TEMP_TIME_0P2S),1 (AICL_RERUN_TEMP_TIME_0P4S),2 (AICL_RERUN_TEMP_TIME_0P8S),3 (AICL_RERUN_TEMP_TIME_1P6S)"
    tree.end
    tree "SMB2CHG_MISC_THERMREG_SRC_CFG"
      sgroup "SMB2CHG_MISC_THERMREG_SRC_CFG (at 0x1670)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SKIN_ADC_CFG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   THERMREG_SKIN_ADC_SRC_EN                 = " "0 (THERMAL_REG_SKIN_ADC_DIS),1 (THERMAL_REG_SKIN_ADC_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   THERMREG_DIE_ADC_SRC_EN                  = " "0 (THERMAL_REG_DIE_ADC_DIS),1 (THERMAL_REG_DIE_ADC_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   THERMREG_DIE_CMP_SRC_EN                  = " "0 (THERMAL_REG_DIE_CMP_DIS),1 (THERMAL_REG_DIE_CMP_EN)"
    tree.end
    tree "SMB2CHG_MISC_TREG_DIE_CMP_INC_CYCLE_TIME_CFG"
      sgroup "SMB2CHG_MISC_TREG_DIE_CMP_INC_CYCLE_TIME_CFG (at 0x1671)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_CMP_INC_CYCLE_TIME              = " "0 (TREG_DIE_CMP_INC_CYCLE_TIME_0P2S),1 (TREG_DIE_CMP_INC_CYCLE_TIME_0P4S),2 (TREG_DIE_CMP_INC_CYCLE_TIME_0P8S),3 (TREG_DIE_CMP_INC_CYCLE_TIME_1P6S)"
    tree.end
    tree "SMB2CHG_MISC_TREG_DIE_CMP_DEC_CYCLE_TIME_CFG"
      sgroup "SMB2CHG_MISC_TREG_DIE_CMP_DEC_CYCLE_TIME_CFG (at 0x1672)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_CMP_DEC_CYCLE_TIME              = " "0 (TREG_DIE_CMP_DEC_CYCLE_TIME_0P2S),1 (TREG_DIE_CMP_DEC_CYCLE_TIME_0P4S),2 (TREG_DIE_CMP_DEC_CYCLE_TIME_0P8S),3 (TREG_DIE_CMP_DEC_CYCLE_TIME_1P6S)"
    tree.end
    tree "SMB2CHG_MISC_TREG_DIE_ADC_INC_CYCLE_TIME_CFG"
      sgroup "SMB2CHG_MISC_TREG_DIE_ADC_INC_CYCLE_TIME_CFG (at 0x1673)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_ADC_INC_CYCLE_TIME              = " "0 (TREG_DIE_ADC_INC_CYCLE_TIME_2S),1 (TREG_DIE_ADC_INC_CYCLE_TIME_4S),2 (TREG_DIE_ADC_INC_CYCLE_TIME_6S),3 (TREG_DIE_ADC_INC_CYCLE_TIME_8S)"
    tree.end
    tree "SMB2CHG_MISC_TREG_DIE_ADC_DEC_CYCLE_TIME_CFG"
      sgroup "SMB2CHG_MISC_TREG_DIE_ADC_DEC_CYCLE_TIME_CFG (at 0x1674)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_DIE_ADC_DEC_CYCLE_TIME              = " "0 (TREG_DIE_ADC_DEC_CYCLE_TIME_2S),1 (TREG_DIE_ADC_DEC_CYCLE_TIME_4S),2 (TREG_DIE_ADC_DEC_CYCLE_TIME_6S),3 (TREG_DIE_ADC_DEC_CYCLE_TIME_8S)"
    tree.end
    tree "SMB2CHG_MISC_TREG_SKIN_ADC_INC_CYCLE_TIME_CFG"
      sgroup "SMB2CHG_MISC_TREG_SKIN_ADC_INC_CYCLE_TIME_CFG (at 0x1675)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_SKIN_ADC_INC_CYCLE_TIME             = " "0 (TREG_SKIN_ADC_INC_CYCLE_TIME_2S),1 (TREG_SKIN_ADC_INC_CYCLE_TIME_4S),2 (TREG_SKIN_ADC_INC_CYCLE_TIME_6S),3 (TREG_SKIN_ADC_INC_CYCLE_TIME_8S)"
    tree.end
    tree "SMB2CHG_MISC_TREG_SKIN_ADC_DEC_CYCLE_TIME_CFG"
      sgroup "SMB2CHG_MISC_TREG_SKIN_ADC_DEC_CYCLE_TIME_CFG (at 0x1676)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TREG_SKIN_ADC_DEC_CYCLE_TIME             = " "0 (TREG_SKIN_ADC_DEC_CYCLE_TIME_2S),1 (TREG_SKIN_ADC_DEC_CYCLE_TIME_4S),2 (TREG_SKIN_ADC_DEC_CYCLE_TIME_6S),3 (TREG_SKIN_ADC_DEC_CYCLE_TIME_8S)"
    tree.end
    tree "SMB2CHG_MISC_BUCK_OPTIONS_CFG"
      sgroup "SMB2CHG_MISC_BUCK_OPTIONS_CFG (at 0x1680)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_EN_PIN_SUSPEND_CFG                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HICCUP_OPTIONS                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INPUT_CURRENT_LIMIT_SOFTSTART_EN         = " "0 (INPUT_CURRENT_LIMIT_SOFTSTART_DIS),1 (INPUT_CURRENT_LIMIT_SOFTSTART_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HV_HIGH_DUTY_CYCLE_PROTECT_EN            = " "0 (HV_HIGH_DUTY_CYCLE_PROTECT_DIS),1 (HV_HIGH_DUTY_CYCLE_PROTECT_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BUCK_OC_PROTECT_EN                       = " "0 (BUCK_OC_PROTECT_DIS),1 (BUCK_OC_PROTECT_EN)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INPUT_MISS_POLL_EN                       = " "0 (INPUT_MISSING_POLLER_DIS),1 (INPUT_MISSING_POLLER_EN)"
    tree.end
    tree "SMB2CHG_MISC_ICL_SOFTSTART_RATE_CFG"
      sgroup "SMB2CHG_MISC_ICL_SOFTSTART_RATE_CFG (at 0x1681)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ICL_SOFTSTART_RATE                       = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_ICL_SOFTSTOP_RATE_CFG"
      sgroup "SMB2CHG_MISC_ICL_SOFTSTOP_RATE_CFG (at 0x1682)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ICL_SOFTSTOP_RATE                        = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_VSYS_MIN_SEL_CFG"
      sgroup "SMB2CHG_MISC_VSYS_MIN_SEL_CFG (at 0x1683)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VSYS_MIN_SEL                             = " "0 (SYSMIN_3P15),1 (SYSMIN_3P45),2 (SYSMIN_3P6),3 (SYSMIN_3P60)"
    tree.end
    tree "SMB2CHG_MISC_TRACKING_VOLTAGE_SEL_CFG"
      sgroup "SMB2CHG_MISC_TRACKING_VOLTAGE_SEL_CFG (at 0x1684)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRACKING_VOLTAGE_SEL                     = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_STAT_IRQ_PULSING_EN_CFG"
      sgroup "SMB2CHG_MISC_STAT_IRQ_PULSING_EN_CFG (at 0x1690)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAT_IRQ_PULSING_EN                      = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_LBC_EN_CFG"
      sgroup "SMB2CHG_MISC_LBC_EN_CFG (at 0x1691)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LBC_DURING_CHARGING_CFG                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LBC_EN                                   = " "0 (INPUT_MISSING_POLLER_DIS),1 (INPUT_MISSING_POLLER_EN)"
    tree.end
    tree "SMB2CHG_MISC_LBC_PERIOD_CFG"
      sgroup "SMB2CHG_MISC_LBC_PERIOD_CFG (at 0x1692)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LBC_PERIOD                               = " "0 (LBC_PERIOD_500MS),1 (LBC_PERIOD_1000MS),2 (LBC_PERIOD_1500MS),3 (LBC_PERIOD_2000MS),4 (LBC_PERIOD_2500MS),5 (LBC_PERIOD_3000MS),6 (LBC_PERIOD_3500MS),7 (LBC_PERIOD_4000MS)"
    tree.end
    tree "SMB2CHG_MISC_LBC_DUTY_CYCLE_CFG"
      sgroup "SMB2CHG_MISC_LBC_DUTY_CYCLE_CFG (at 0x1693)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LBC_DUTY_CYCLE                           = " "0 (LBC_DUTY_CYCLE_0PCT),1 (LBC_DUTY_CYCLE_12P5PCT),2 (LBC_DUTY_CYCLE_25PCT),3 (LBC_DUTY_CYCLE_37P5PCT),4 (LBC_DUTY_CYCLE_50PCT),5 (LBC_DUTY_CYCLE_62P5PCT),6 (LBC_DUTY_CYCLE_75PCT),7 (LBC_DUTY_CYCLE_100PCT)"
    tree.end
    tree "SMB2CHG_MISC_SYSOK_CFG"
      sgroup "SMB2CHG_MISC_SYSOK_CFG (at 0x1694)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SYSOK_PUSHPULL_CFG                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SYSOK_B_OR_C_SEL                         = " "0 (SYSOK_OPT_B),1 (SYSOK_OPT_C)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYSOK_POL                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SYSOK_OPTIONS                            = " "0 (INOK_OPT_1),1 (INOK_OPT_2),2 (SYSOK_OPT_A_1),3 (SYSOK_OPT_A_2),4 (SYSOK_OPT_BC_1),5 (SYSOK_OPT_BC_2),6 (CHG_DET_OPT_1),7 (CHG_DET_OPT_2)"
    tree.end
    tree "SMB2CHG_MISC_CUST_SDCDC_CLK_CFG"
      sgroup "SMB2CHG_MISC_CUST_SDCDC_CLK_CFG (at 0x16a0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016a00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16a00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CUST_SDCDC_CLK_CFG                       = "
    tree.end
    tree "SMB2CHG_MISC_CUST_SDCDC_ILIMIT_CFG"
      sgroup "SMB2CHG_MISC_CUST_SDCDC_ILIMIT_CFG (at 0x16a1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016a10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16a10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CUST_SDCDC_ILIMIT_CFG                    = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_CUST_SDCDC_OTG_REF"
      sgroup "SMB2CHG_MISC_CUST_SDCDC_OTG_REF (at 0x16a2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016a20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16a20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CUST_SDCDC_OTG_REF                       = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG1"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG1 (at 0x16c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_SDCDC_REFRESH_CYCLES                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   ENG_SDCDC_REFRESH_TIME                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ENG_SDCDC_HI_BW                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG2"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG2 (at 0x16c1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_SDCDC_BST_BW                         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_SDCDC_EN_SM_SLOPE_RES                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_SDCDC_SHORTMINONTIME                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   ENG_SDCDC_SHORTMINOFFTIME                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_SDCDC_SEL_OOB_VTH                    = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG3"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG3 (at 0x16c2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_SDCDC_FOLDBACK_COUNT                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_SDCDC_EN_HSUVLO                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_SDCDC_EN_STRONG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENG_SDCDC_SYSON_IBIAS                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_SDCDC_SYSON_FB                       = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG4"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG4 (at 0x16c3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ENG_SDCDC_SLOPE                          = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_SDCDC_DIS_AZ_CL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENG_SDCDC_DIS_AZ_ZC                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ENG_SDCDC_DIS_AZ_PWM                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_SDCDC_OV_OPTION                      = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG5"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG5 (at 0x16c4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENG_SDCDC_DIS_SS_BOOST                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ENG_SDCDC_BOOST_SS_SEL                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ENG_SDCDC_DIS_SS_BUCK                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ENG_SDCDC_BUCK_SS_SEL                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG6"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG6 (at 0x16c5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_SDCDC_RISING_EDGE_DEAD_TIME          = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ENG_SDCDC_FALLING_EDGE_DEAD_TIME         = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENG_SDCDC_ISENSE_GAIN_OTG                = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ENG_SDCDC_FOLDBACK_LEVEL                 = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG7"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG7 (at 0x16c6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_SDCDC_BST_SET_POINT                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ENG_SDCDC_IGNORE_VDDCAP_READY            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENG_SDCDC_BP_DRV_LSOFF                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ENG_SDCDC_LS_ILIM                        = "
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_CFG8"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_CFG8 (at 0x16c7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ENG_SDCDC_OTG_SPARES                     = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ENG_SDCDC_SLOPE_OTG                      = "
    tree.end
    tree "SMB2CHG_MISC_ENG_SDCDC_1381_SELECT_CFG"
      sgroup "SMB2CHG_MISC_ENG_SDCDC_1381_SELECT_CFG (at 0x16c8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   ENG_SDCDC_SEL_REF_CONCURRENT             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENG_SDCDC_1381_SELECT                    = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_SEC_ACCESS"
      sgroup "SMB2CHG_MISC_SEC_ACCESS (at 0x16d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMB2CHG_MISC_PERPH_RESET_CTL2"
      sgroup "SMB2CHG_MISC_PERPH_RESET_CTL2 (at 0x16d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_PERPH_RESET_CTL3"
      sgroup "SMB2CHG_MISC_PERPH_RESET_CTL3 (at 0x16da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_PERPH_RESET_CTL4"
      sgroup "SMB2CHG_MISC_PERPH_RESET_CTL4 (at 0x16db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_SPARE"
      sgroup "SMB2CHG_MISC_SPARE (at 0x16df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_INT_TEST1"
      sgroup "SMB2CHG_MISC_INT_TEST1 (at 0x16e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_INT_TEST_VAL"
      sgroup "SMB2CHG_MISC_INT_TEST_VAL (at 0x16e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SWITCHER_POWER_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMPERATURE_CHANGE_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   INPUT_CURRENT_LIMITING_VAL               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   HIGH_DUTY_CYCLE_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AICL_DONE_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL_FAIL_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_BARK_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_SNARL_VAL                           = " "0, 1"
    tree.end
    tree "SMB2CHG_MISC_ATEST1_SEL"
      sgroup "SMB2CHG_MISC_ATEST1_SEL (at 0x16e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST1_OUTPUT_ENABLE                     = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ATEST1_SEL                               = "
    tree.end
    tree "SMB2CHG_MISC_ATEST2_SEL"
      sgroup "SMB2CHG_MISC_ATEST2_SEL (at 0x16e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_OUTPUT_ENABLE                     = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ATEST2_SEL                               = "
    tree.end
    tree "SMB2CHG_MISC_DTEST1_SEL"
      sgroup "SMB2CHG_MISC_DTEST1_SEL (at 0x16e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST1_SEL                               = "
    tree.end
    tree "SMB2CHG_MISC_DTEST2_SEL"
      sgroup "SMB2CHG_MISC_DTEST2_SEL (at 0x16e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST2_SEL                               = "
    tree.end
    tree "SMB2CHG_MISC_DTEST3_SEL"
      sgroup "SMB2CHG_MISC_DTEST3_SEL (at 0x16e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST3_SEL                               = "
    tree.end
    tree "SMB2CHG_MISC_DTEST4_SEL"
      sgroup "SMB2CHG_MISC_DTEST4_SEL (at 0x16e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DTEST4_SEL                               = "
    tree.end
    tree "SMB2CHG_MISC_DTEST_SEL_EXT"
      sgroup "SMB2CHG_MISC_DTEST_SEL_EXT (at 0x16e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DTEST4_SEL_EXT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   DTEST3_SEL_EXT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DTEST2_SEL_EXT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   DTEST1_SEL_EXT                           = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_MISC_TM_SDCDC_0"
      sgroup "SMB2CHG_MISC_TM_SDCDC_0 (at 0x16e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TM_SDCDC_DIS_HS_ILIM_PH1                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_SDCDC_DIS_HS_ILIM_PH2                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_SDCDC_RAMP_OFFSET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_SDCDC_50DC                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TM_SDCDC_FET_CNTL                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_MISC_TM_SDCDC_1"
      sgroup "SMB2CHG_MISC_TM_SDCDC_1 (at 0x16ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_SDCDC_TEST_AZ                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TM_SDCDC_ERROR_AMPS                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_HS_CBC_ILIMIT_P1"
      sgroup "SMB2CHG_MISC_TR_SDCDC_HS_CBC_ILIMIT_P1 (at 0x16f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SDCDC_HS_CBC_ILIMIT_P1                = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_HS_CBC_ILIMIT_P2"
      sgroup "SMB2CHG_MISC_TR_SDCDC_HS_CBC_ILIMIT_P2 (at 0x16f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SDCDC_HS_CBC_ILIMIT_P2                = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_RAMPGAIN_P1"
      sgroup "SMB2CHG_MISC_TR_SDCDC_RAMPGAIN_P1 (at 0x16f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_RAMPGAIN_P1                     = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_RAMPGAIN_P2"
      sgroup "SMB2CHG_MISC_TR_SDCDC_RAMPGAIN_P2 (at 0x16f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_RAMPGAIN_P2                     = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_SLOPE_CAP_P1"
      sgroup "SMB2CHG_MISC_TR_SDCDC_SLOPE_CAP_P1 (at 0x16f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_SLOPE_CAP_P1                    = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_SLOPE_CAP_P2"
      sgroup "SMB2CHG_MISC_TR_SDCDC_SLOPE_CAP_P2 (at 0x16f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_SLOPE_CAP_P2                    = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_ZEROCROSS_P1"
      sgroup "SMB2CHG_MISC_TR_SDCDC_ZEROCROSS_P1 (at 0x16f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SDCDC_ZEROCROSS_P1                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_ZEROCROSS_P2"
      sgroup "SMB2CHG_MISC_TR_SDCDC_ZEROCROSS_P2 (at 0x16f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SDCDC_ZEROCROSS_P2                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_BUCK_OSC"
      sgroup "SMB2CHG_MISC_TR_SDCDC_BUCK_OSC (at 0x16f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_BUCK_OSC                        = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_PWM_COMP_OFFSET_P1"
      sgroup "SMB2CHG_MISC_TR_SDCDC_PWM_COMP_OFFSET_P1 (at 0x16f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SDCDC_PWM_COMP_OFFSET_P1              = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_PWM_COMP_OFFSET_P2"
      sgroup "SMB2CHG_MISC_TR_SDCDC_PWM_COMP_OFFSET_P2 (at 0x16fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SDCDC_PWM_COMP_OFFSET_P2              = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_RAMP_OFFSET_PH1"
      sgroup "SMB2CHG_MISC_TR_SDCDC_RAMP_OFFSET_PH1 (at 0x16fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_RAMP_OFFSET_PH1                 = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_RAMP_OFFSET_PH2"
      sgroup "SMB2CHG_MISC_TR_SDCDC_RAMP_OFFSET_PH2 (at 0x16fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SDCDC_RAMP_OFFSET_PH2                 = "
    tree.end
    tree "SMB2CHG_MISC_TR_SDCDC_SPARE_OTG"
      sgroup "SMB2CHG_MISC_TR_SDCDC_SPARE_OTG (at 0x16fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_SDCDC_SPARE_OTG                       = "
    tree.end
  tree.end
tree.end
tree "SMB2CHG_OTG"
  tree "SMB2CHG_OTG"
    tree "SMB2CHG_OTG_PERPH_TYPE"
      sgroup "SMB2CHG_OTG_PERPH_TYPE (at 0x1104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMB2CHG_OTG_PERPH_SUBTYPE"
      sgroup "SMB2CHG_OTG_PERPH_SUBTYPE (at 0x1105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMB2CHG_OTG_RID_CC_CONTROL_23_16"
      sgroup "SMB2CHG_OTG_RID_CC_CONTROL_23_16 (at 0x1106)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RID_CC_CONTROL_23                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VCONN_SOFTSTART_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VCONN_SFTST_CFG                          = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   CONNECT_RIDCC_SENSOR_TO_CC               = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_CC_1P1CLAMP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_CRUDESEN_CC_1                     = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_RID_CC_CONTROL_15_8"
      sgroup "SMB2CHG_OTG_RID_CC_CONTROL_15_8 (at 0x1107)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_CRUDESEN_CC_0                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   EN_FMB_2P5UA_CC                          = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_ISRC_180UA                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ENABLE_CURRENTSOURCE_CC                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_BANDGAP_RID_C_DET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_RD_CC_1                           = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_RID_CC_CONTROL_7_0"
      sgroup "SMB2CHG_OTG_RID_CC_CONTROL_7_0 (at 0x1108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_RD_CC_0                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VCONN_ILIM500MA                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_MICRO_USB_MODE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UFP_DFP_MODE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   VCONN_EN_CC                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VREF_SEL_RIDCC_SENSOR                    = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_OTG_OTG_STATUS"
      sgroup "SMB2CHG_OTG_OTG_STATUS (at 0x1109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BOOST_SOFTSTART_DONE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   OTG_STATE                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMB2CHG_OTG_INT_RT_STS"
      sgroup "SMB2CHG_OTG_INT_RT_STS (at 0x1110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_RT_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_RT_STS                          = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_SET_TYPE"
      sgroup "SMB2CHG_OTG_INT_SET_TYPE (at 0x1111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_TYPE                            = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_POLARITY_HIGH"
      sgroup "SMB2CHG_OTG_INT_POLARITY_HIGH (at 0x1112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_HIGH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_HIGH                            = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_POLARITY_LOW"
      sgroup "SMB2CHG_OTG_INT_POLARITY_LOW (at 0x1113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_LOW               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LOW                             = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_LATCHED_CLR"
      sgroup "SMB2CHG_OTG_INT_LATCHED_CLR (at 0x1114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_LATCHED_CLR       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_EN_SET"
      sgroup "SMB2CHG_OTG_INT_EN_SET (at 0x1115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_EN_SET            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_EN_SET                          = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_EN_CLR"
      sgroup "SMB2CHG_OTG_INT_EN_CLR (at 0x1116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_EN_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_LATCHED_STS"
      sgroup "SMB2CHG_OTG_INT_LATCHED_STS (at 0x1118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_LATCHED_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_PENDING_STS"
      sgroup "SMB2CHG_OTG_INT_PENDING_STS (at 0x1119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_DETECT_PENDING_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_STS_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_MID_SEL"
      sgroup "SMB2CHG_OTG_INT_MID_SEL (at 0x111a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x80111a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x111a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_OTG_INT_PRIORITY"
      sgroup "SMB2CHG_OTG_INT_PRIORITY (at 0x111b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x80111b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x111b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_CMD_OTG"
      sgroup "SMB2CHG_OTG_CMD_OTG (at 0x1140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_EN                                   = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_BAT_UVLO_THRESHOLD_CFG"
      sgroup "SMB2CHG_OTG_BAT_UVLO_THRESHOLD_CFG (at 0x1151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_UVLO_THRESHOLD                       = " "0 (OTG_BATTUV_2P7),1 (OTG_BATTUV_2P9),2 (OTG_BATTUV_3P1),3 (OTG_BATTUV_3P3)"
    tree.end
    tree "SMB2CHG_OTG_OTG_CURRENT_LIMIT_CFG"
      sgroup "SMB2CHG_OTG_OTG_CURRENT_LIMIT_CFG (at 0x1152)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   OTG_CURRENT_LIMIT                        = " "0 (OTG_ILIMIT_250MA),1 (OTG_ILIMIT_600MA),2 (OTG_ILIMIT_750MA),3 (OTG_ILIMIT_1000MA),4 (reserved),5 (reserved),6 (reserved),7 (reserved)"
    tree.end
    tree "SMB2CHG_OTG_OTG_CFG"
      sgroup "SMB2CHG_OTG_OTG_CFG (at 0x1153)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   OTG_RESERVED                             = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INCREASE_DFP_TIME                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ENABLE_OTG_IN_DEBUG_MODE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_EN_SRC_CFG                           = " "0 (OTG_ENABLE_SRC_CMD),1 (OTG_ENABLE_SRC_TYPEC)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONCURRENT_MODE_CFG                      = " "0 (OTG_CONCURRENT_DIS),1 (OTG_CONCURRENT_EN)"
    tree.end
    tree "SMB2CHG_OTG_SEC_ACCESS"
      sgroup "SMB2CHG_OTG_SEC_ACCESS (at 0x11d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMB2CHG_OTG_PERPH_RESET_CTL2"
      sgroup "SMB2CHG_OTG_PERPH_RESET_CTL2 (at 0x11d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_PERPH_RESET_CTL3"
      sgroup "SMB2CHG_OTG_PERPH_RESET_CTL3 (at 0x11da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_PERPH_RESET_CTL4"
      sgroup "SMB2CHG_OTG_PERPH_RESET_CTL4 (at 0x11db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_SPARE"
      sgroup "SMB2CHG_OTG_SPARE (at 0x11df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_OTG_INT_TEST1"
      sgroup "SMB2CHG_OTG_INT_TEST1 (at 0x11e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_INT_TEST_VAL"
      sgroup "SMB2CHG_OTG_INT_TEST_VAL (at 0x11e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TESTMODE_CHANGE_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OTG_OC_DIS_SW_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTG_OVERCURRENT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_FAIL_VAL                             = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_TEST_EN_CFG"
      sgroup "SMB2CHG_OTG_TEST_EN_CFG (at 0x11e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TESTMODE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TM_USE_EXT_CLK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TEST_INPUT_MUX_ENABLE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEST_OUTPUT_MUX_ENABLE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_REGISTER_PASS_THRU                  = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_TM_OTG"
      sgroup "SMB2CHG_OTG_TM_OTG (at 0x11e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TM_OTG_FAULT_SOURCE_DISABLE              = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_VDIODE_THRESHOLD"
      sgroup "SMB2CHG_OTG_TR_SBQ_VDIODE_THRESHOLD (at 0x11f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_SBQ_VDIODE_THRESHOLD                  = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_SOFT_ILIMIT"
      sgroup "SMB2CHG_OTG_TR_SBQ_SOFT_ILIMIT (at 0x11f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_SBQ_SOFT_ILIMIT                       = " "0, 1"
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_VCHG_BUFFER_OFFSET"
      sgroup "SMB2CHG_OTG_TR_SBQ_VCHG_BUFFER_OFFSET (at 0x11f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_SBQ_VCHG_BUFFER_OFFSET                = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SBQ_VDISCHG_BUFFER_OFFSET             = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_OCP_OFFSET"
      sgroup "SMB2CHG_OTG_TR_SBQ_OCP_OFFSET (at 0x11f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_OCP_OFFSET                        = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_OTG_OFFSET"
      sgroup "SMB2CHG_OTG_TR_SBQ_OTG_OFFSET (at 0x11f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_OTG_OFFSET                        = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_ICL_1X_REF_OFFSET"
      sgroup "SMB2CHG_OTG_TR_SBQ_ICL_1X_REF_OFFSET (at 0x11f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_ICL_1X_REF_OFFSET                 = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_ICL_8X_REF_OFFSET"
      sgroup "SMB2CHG_OTG_TR_SBQ_ICL_8X_REF_OFFSET (at 0x11f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_ICL_8X_REF_OFFSET                 = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_IDISCHGCS_GAIN"
      sgroup "SMB2CHG_OTG_TR_SBQ_IDISCHGCS_GAIN (at 0x11f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SBQ_IDISCHGCS_GAIN                    = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_IDISCHGCS_OFFSET"
      sgroup "SMB2CHG_OTG_TR_SBQ_IDISCHGCS_OFFSET (at 0x11f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_IDISCHGCS_OFFSET                  = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_VCHG_BUFFER_GAIN"
      sgroup "SMB2CHG_OTG_TR_SBQ_VCHG_BUFFER_GAIN (at 0x11f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_SBQ_VCHG_BUFFER_GAIN                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_SBQ_VDISCHG_BUFFER_GAIN               = "
    tree.end
    tree "SMB2CHG_OTG_TR_SBQ_BATN_OFFSET"
      sgroup "SMB2CHG_OTG_TR_SBQ_BATN_OFFSET (at 0x11fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_SBQ_BATN_OFFSET                       = "
    tree.end
  tree.end
tree.end
tree "SMB2CHG_USB"
  tree "SMB2CHG_USB"
    tree "SMB2CHG_USB_PERPH_TYPE"
      sgroup "SMB2CHG_USB_PERPH_TYPE (at 0x1304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMB2CHG_USB_PERPH_SUBTYPE"
      sgroup "SMB2CHG_USB_PERPH_SUBTYPE (at 0x1305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMB2CHG_USB_USBIN_INPUT_STATUS"
      sgroup "SMB2CHG_USB_USBIN_INPUT_STATUS (at 0x1306)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   USBIN_INPUT_STATUS_7                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_INPUT_STATUS_6                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_12V                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_9V_TO_12V                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_9V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_5V_TO_12V                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_5V_TO_9V                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_5V                                 = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_APSD_STATUS"
      sgroup "SMB2CHG_USB_APSD_STATUS (at 0x1307)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   APSD_STATUS_7                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   APSD_STATUS_6                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SLOW_PLUGIN_TIMEOUT                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENUMERATION_DONE                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VADP_CHANGE_DONE_AFTER_AUTH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   QC_AUTH_DONE_STATUS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   QC_CHARGER                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   APSD_DTC_STATUS_DONE                     = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_APSD_RESULT_STATUS"
      sgroup "SMB2CHG_USB_APSD_RESULT_STATUS (at 0x1308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ICL_OVERRIDE_LATCH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QC_3P0                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QC_2P0                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FLOAT_CHARGER                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCP_CHARGER                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CDP_CHARGER                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCP_CHARGER                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SDP_CHARGER                              = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_QC_CHANGE_STATUS"
      sgroup "SMB2CHG_USB_QC_CHANGE_STATUS (at 0x1309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QC_CHANGE_STATUS_7                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QC_CHANGE_STATUS_6                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   QC_9V_TO_12V_REASON                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QC_5V_TO_9V_REASON                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   QC_CONTINUOUS                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   QC_12V                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   QC_9V                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   QC_5V                                    = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_QC_PULSE_COUNT_STATUS"
      sgroup "SMB2CHG_USB_QC_PULSE_COUNT_STATUS (at 0x130a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   QC_PULSE_COUNT_STATUS_7                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   QC_PULSE_COUNT_STATUS_6                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   QC_PULSE_COUNT                           = "
    tree.end
    tree "SMB2CHG_USB_TYPE_C_STATUS_1"
      sgroup "SMB2CHG_USB_TYPE_C_STATUS_1 (at 0x130b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UFP_TYPEC_RDSTD                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   UFP_TYPEC_RD1P5                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UFP_TYPEC_RD3P0                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UFP_TYPEC_FMB_255K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   UFP_TYPEC_FMB_301K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UFP_TYPEC_FMB_523K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UFP_TYPEC_FMB_619K                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   UFP_TYPEC_OPEN_OPEN                      = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TYPE_C_STATUS_2"
      sgroup "SMB2CHG_USB_TYPE_C_STATUS_2 (at 0x130c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_STATUS_2_7                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TIMER_STAGE                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EXIT_UFP_MODE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EXIT_DFP_MODE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DFP_RD_OPEN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DFP_RD_RA_VCONN                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DFP_RD_RD                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DFP_RA_RA                                = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TYPE_C_STATUS_3"
      sgroup "SMB2CHG_USB_TYPE_C_STATUS_3 (at 0x130d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ENABLE_BANDGAP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   U_USB_GROUND_NOVBUS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   U_USB_FLOAT_NOVBUS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   U_USB_GROUND                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   U_USB_FMB1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   U_USB_FLOAT1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   U_USB_FMB2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   U_USB_FLOAT2                             = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TYPE_C_STATUS_4"
      sgroup "SMB2CHG_USB_TYPE_C_STATUS_4 (at 0x130e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UFP_DFP_MODE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPEC_VBUS_STATUS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_VBUS_ERROR_STATUS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPEC_DEBOUNCE_DONE_STATUS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TYPEC_UFP_AUDIO_ADAPT_STATUS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TYPEC_VCONN_OVERCURR_STATUS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CCOUT_OUT                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CCOUT_OUT_HIZ                            = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_RT_STS"
      sgroup "SMB2CHG_USB_INT_RT_STS (at 0x1310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_RT_STS    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_RT_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_RT_STS               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_RT_STS                    = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_SET_TYPE"
      sgroup "SMB2CHG_USB_INT_SET_TYPE (at 0x1311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_TYPE      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_TYPE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_TYPE                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_TYPE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_TYPE                      = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_POLARITY_HIGH"
      sgroup "SMB2CHG_USB_INT_POLARITY_HIGH (at 0x1312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_HIGH      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_HIGH                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_HIGH                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_HIGH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_HIGH                      = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_POLARITY_LOW"
      sgroup "SMB2CHG_USB_INT_POLARITY_LOW (at 0x1313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_LOW       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_LOW                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_LOW                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_LOW                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_LOW                       = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_LATCHED_CLR"
      sgroup "SMB2CHG_USB_INT_LATCHED_CLR (at 0x1314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_LATCHED_CLR = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_LATCHED_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_LATCHED_CLR               = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_EN_SET"
      sgroup "SMB2CHG_USB_INT_EN_SET (at 0x1315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_EN_SET    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_EN_SET               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_EN_SET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_EN_SET                    = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_EN_CLR"
      sgroup "SMB2CHG_USB_INT_EN_CLR (at 0x1316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_EN_CLR    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGEL_EN_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_EN_CLR                    = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_LATCHED_STS"
      sgroup "SMB2CHG_USB_INT_LATCHED_STS (at 0x1318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_LATCHED_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_LATCHED_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_LATCHED_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_LATCHED_STS               = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_PENDING_STS"
      sgroup "SMB2CHG_USB_INT_PENDING_STS (at 0x1319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_PENDING_STS = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_PENDING_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_PENDING_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_PENDING_STS               = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_MID_SEL"
      sgroup "SMB2CHG_USB_INT_MID_SEL (at 0x131a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_USB_INT_PRIORITY"
      sgroup "SMB2CHG_USB_INT_PRIORITY (at 0x131b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_CMD_IL"
      sgroup "SMB2CHG_USB_CMD_IL (at 0x1340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   BAT_2_SYS_FET_DIS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_SUSPEND                            = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_CMD_APSD"
      sgroup "SMB2CHG_USB_CMD_APSD (at 0x1341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ICL_OVERRIDE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   APSD_RERUN                               = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_CMD_HVDCP_2"
      sgroup "SMB2CHG_USB_CMD_HVDCP_2 (at 0x1343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_AICL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_12V                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FORCE_9V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_5V                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   IDLE                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SINGLE_DECREMENT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SINGLE_INCREMENT                         = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_USB_MISC2"
      sgroup "SMB2CHG_USB_USB_MISC2 (at 0x1357)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   USB_MISC2                                = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_USB_TYPE_C_CFG"
      sgroup "SMB2CHG_USB_TYPE_C_CFG (at 0x1358)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   APSD_START_ON_CC                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WAIT_FOR_APSD                            = " "0 (APSD_NO_WAIT),1 (APSD_WAIT)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FACTORY_MODE_DETECTION_EN                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FACTORY_MODE_ICL_3A_4A                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FACTORY_MODE_DIS_CHGING_CFG              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SUSPEND_NON_COMPLIANT_CFG                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VCONN_OC_CFG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TYPE_C_OR_U_USB                          = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TYPE_C_CFG_2"
      sgroup "SMB2CHG_USB_TYPE_C_CFG_2 (at 0x1359)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VCONN_ILIM500MA_CFG                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   VCONN_SOFTSTART_CFG                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EN_TRY_SOURCE_MODE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB_FACTORY_MODE_ENABLE                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TYPE_C_UFP_MODE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EN_80UA_180UA_CUR_SOURCE                 = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_USBIN_ADAPTER_ALLOW_CFG"
      sgroup "SMB2CHG_USB_USBIN_ADAPTER_ALLOW_CFG (at 0x1360)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   USBIN_ADAPTER_ALLOW                      = "
    tree.end
    tree "SMB2CHG_USB_USBIN_OPTIONS_1_CFG"
      sgroup "SMB2CHG_USB_USBIN_OPTIONS_1_CFG (at 0x1362)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CABLE_R_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   HVDCP_AUTH_ALG_EN_CFG                    = " "0 (HVDCP_AUTH_DIS),1 (HVDCP_AUTH_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HVDCP_AUTONOMOUS_MODE_EN_CFG             = " "0 (AUTO_INC_COMMAND),1 (AUTO_INC_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   INPUT_PRIORITY                           = " "0 (DCIN_PRIORITY),1 (USBIN_PRIORITY)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   AUTO_SRC_DETECT                          = " "0 (AUTO_SRC_DETECT_DIS),1 (AUTO_SRC_DETECT_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HVDCP_EN                                 = " "0 (HVDCP_DISABLE),1 (HVDCP_ENABLE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   VADP_INCREMENT_VOLTAGE_LIMIT             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VADP_TAPER_TIMER_EN                      = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_USBIN_OPTIONS_2_CFG"
      sgroup "SMB2CHG_USB_USBIN_OPTIONS_2_CFG (at 0x1363)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SWITCHER_START_CFG                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DCD_TIMEOUT_SEL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OCD_CURRENT_SEL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SLOW_PLUGIN_TIMER_EN_CFG                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FLOAT_DIS_CHGING_CFG                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SUSPEND_FLOAT_CFG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_FLOAT_SDP_CFG                      = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TAPER_TIMER_SEL_CFG"
      sgroup "SMB2CHG_USB_TAPER_TIMER_SEL_CFG (at 0x1364)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TAPER_TIMER_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_USB_USBIN_LOAD_CFG"
      sgroup "SMB2CHG_USB_USBIN_LOAD_CFG (at 0x1365)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_OV_CH_LOAD_OPTION                  = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_USBIN_ICL_OPTIONS"
      sgroup "SMB2CHG_USB_USBIN_ICL_OPTIONS (at 0x1366)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_USB3P0_SEL                           = " "0 (USB_2P0_SEL),1 (USB_3P0_SEL)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51_MODE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_MODE_CHG                           = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TYPE_C_INTRPT_ENB"
      sgroup "SMB2CHG_USB_TYPE_C_INTRPT_ENB (at 0x1367)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPEC_CCOUT_DETACH_INT_EN                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TYPEC_CCOUT_ATTACH_INT_EN                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_VBUS_ERROR_INT_EN                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TYPEC_UFP_AUDIOADAPT_INT_EN              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TYPEC_DEBOUNCE_DONE_INT_EN               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TYPEC_CCSTATE_CHANGE_INT_EN              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TYPEC_VBUS_DEASSERT_INT_EN               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TYPEC_VBUS_ASSERT_INT_EN                 = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TYPE_C_INTRPT_ENB_SOFTWARE_CTRL"
      sgroup "SMB2CHG_USB_TYPE_C_INTRPT_ENB_SOFTWARE_CTRL (at 0x1368)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TYPEC_VCONN_OVERCURR_INT_EN              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VCONN_EN_SRC                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VCONN_EN_VALUE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   UFP_EN_CMD                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DFP_EN_CMD                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TYPEC_DISABLE_CMD                        = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_USBIN_SOURCE_CHANGE_INTRPT_ENB"
      sgroup "SMB2CHG_USB_USBIN_SOURCE_CHANGE_INTRPT_ENB (at 0x1369)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SLOW_IRQ_EN_CFG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ENUMERATION_IRQ_EN_CFG                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VADP_IRQ_EN_CFG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTH_IRQ_EN_CFG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HVDCP_IRQ_EN_CFG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   APSD_IRQ_EN_CFG                          = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_USBIN_CURRENT_LIMIT_CFG"
      sgroup "SMB2CHG_USB_USBIN_CURRENT_LIMIT_CFG (at 0x1370)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USBIN_CURRENT_LIMIT                      = "
    tree.end
    tree "SMB2CHG_USB_USBIN_AICL_OPTIONS_CFG"
      sgroup "SMB2CHG_USB_USBIN_AICL_OPTIONS_CFG (at 0x1380)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SUSPEND_ON_COLLAPSE_USBIN                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_AICL_HDC_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_AICL_START_AT_MAX                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_AICL_RERUN_EN                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_AICL_ADC_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_AICL_EN                            = " "0 (USBIN_AICL_DISABLED),1 (USBIN_AICL_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_HV_COLLAPSE_RESPONSE               = " "0 (USBIN_COLLAPSE_HV_FET_ON),1 (USBIN_COLLAPSE_HV_FET_OFF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_LV_COLLAPSE_RESPONSE               = " "0 (USBIN_COLLAPSE_LV_FET_ON),1 (USBIN_COLLAPSE_LV_FET_OFF)"
    tree.end
    tree "SMB2CHG_USB_USBIN_AICL_REF_SEL_CFG"
      sgroup "SMB2CHG_USB_USBIN_AICL_REF_SEL_CFG (at 0x1381)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   USBIN_AICL_CONT_TRIP                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_AICL_5V_TRIP                       = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_ENG_SCPATH_CFG"
      sgroup "SMB2CHG_USB_ENG_SCPATH_CFG (at 0x13c0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ENG_SCPATH_CFG                           = "
    tree.end
    tree "SMB2CHG_USB_SEC_ACCESS"
      sgroup "SMB2CHG_USB_SEC_ACCESS (at 0x13d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMB2CHG_USB_PERPH_RESET_CTL2"
      sgroup "SMB2CHG_USB_PERPH_RESET_CTL2 (at 0x13d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_PERPH_RESET_CTL3"
      sgroup "SMB2CHG_USB_PERPH_RESET_CTL3 (at 0x13da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_PERPH_RESET_CTL4"
      sgroup "SMB2CHG_USB_PERPH_RESET_CTL4 (at 0x13db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_SPARE"
      sgroup "SMB2CHG_USB_SPARE (at 0x13df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RFU                                      = " "0, 1, 2, 3"
    tree.end
    tree "SMB2CHG_USB_INT_TEST1"
      sgroup "SMB2CHG_USB_INT_TEST1 (at 0x13e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_INT_TEST_VAL"
      sgroup "SMB2CHG_USB_INT_TEST_VAL (at 0x13e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TYPE_C_OR_RID_DETECTION_CHANGE_VAL       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_ICL_CHANGE_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_SOURCE_CHANGE_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_PLUGIN_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_OV_VAL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_UV_VAL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_LT_3P6V_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_COLLAPSE_VAL                       = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TM_SCPATH_ISNS"
      sgroup "SMB2CHG_USB_TM_SCPATH_ISNS (at 0x13e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_SCPATH_ISNS                           = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_7_0"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_7_0 (at 0x13e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_7_0                         = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_15_8"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_15_8 (at 0x13e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_15_8                        = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_23_16"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_23_16 (at 0x13e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_23_16                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_31_24"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_31_24 (at 0x13e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_31_24                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_39_32"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_39_32 (at 0x13e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_39_32                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_47_40"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_47_40 (at 0x13e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_47_40                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_55_48"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_55_48 (at 0x13e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_55_48                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_63_56"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_63_56 (at 0x13ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_63_56                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_71_64"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_71_64 (at 0x13eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_71_64                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_79_72"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_79_72 (at 0x13ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_79_72                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_87_80"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_87_80 (at 0x13ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_87_80                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_95_88"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_95_88 (at 0x13ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_OUT_TEST_95_88                       = "
    tree.end
    tree "SMB2CHG_USB_CHG_OUT_TEST_103_96"
      sgroup "SMB2CHG_USB_CHG_OUT_TEST_103_96 (at 0x13ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CHG_OUT_TEST_103_96                      = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_ICL_8X_GAIN_CH1"
      sgroup "SMB2CHG_USB_TR_SCPATH_ICL_8X_GAIN_CH1 (at 0x13f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_ICL_8X_GAIN_CH1                = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_ICL_8X_OFFSET_CH1"
      sgroup "SMB2CHG_USB_TR_SCPATH_ICL_8X_OFFSET_CH1 (at 0x13f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_ICL_8X_OFFSET_CH1              = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_ICL_1X_GAIN_CH1"
      sgroup "SMB2CHG_USB_TR_SCPATH_ICL_1X_GAIN_CH1 (at 0x13f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_ICL_1X_GAIN_CH1                = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_ICL_GAIN_CH2"
      sgroup "SMB2CHG_USB_TR_SCPATH_ICL_GAIN_CH2 (at 0x13f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_ICL_GAIN_CH2                   = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_ICL_1X_OFFSET_CH1"
      sgroup "SMB2CHG_USB_TR_SCPATH_ICL_1X_OFFSET_CH1 (at 0x13f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_ICL_1X_OFFSET_CH1              = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_ICL_OFFSET_CH2"
      sgroup "SMB2CHG_USB_TR_SCPATH_ICL_OFFSET_CH2 (at 0x13f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_ICL_OFFSET_CH2                 = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_OTG_SNS_OFFSET"
      sgroup "SMB2CHG_USB_TR_SCPATH_OTG_SNS_OFFSET (at 0x13f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_OTG_SNS_OFFSET                 = "
    tree.end
    tree "SMB2CHG_USB_TR_SCPATH_OTG_SNS_GAIN"
      sgroup "SMB2CHG_USB_TR_SCPATH_OTG_SNS_GAIN (at 0x13f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_SCPATH_OTG_SNS_GAIN                   = "
    tree.end
    tree "SMB2CHG_USB_TR_OTG_SPARE_0"
      sgroup "SMB2CHG_USB_TR_OTG_SPARE_0 (at 0x13f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_OTG_SPARE_0                           = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TR_OTG_SPARE_1"
      sgroup "SMB2CHG_USB_TR_OTG_SPARE_1 (at 0x13f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_OTG_SPARE_1                           = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TR_OTG_SPARE_2"
      sgroup "SMB2CHG_USB_TR_OTG_SPARE_2 (at 0x13fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_OTG_SPARE_2                           = " "0, 1"
    tree.end
    tree "SMB2CHG_USB_TR_OTG_SPARE_3"
      sgroup "SMB2CHG_USB_TR_OTG_SPARE_3 (at 0x13fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_OTG_SPARE_3                           = " "0, 1"
    tree.end
  tree.end
tree.end
tree "TADC"
  tree "TADC"
    tree "TADC_REVISION1"
      sgroup "TADC_REVISION1 (at 0x3600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TADC_REVISION2"
      sgroup "TADC_REVISION2 (at 0x3601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TADC_REVISION3"
      sgroup "TADC_REVISION3 (at 0x3602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TADC_REVISION4"
      sgroup "TADC_REVISION4 (at 0x3603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TADC_PERPH_TYPE"
      sgroup "TADC_PERPH_TYPE (at 0x3604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TADC_PERPH_SUBTYPE"
      sgroup "TADC_PERPH_SUBTYPE (at 0x3605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TADC_SW_CH_CONV"
      sgroup "TADC_SW_CH_CONV (at 0x3606)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036060
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36060
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
    tree "TADC_MBG_ERR"
      sgroup "TADC_MBG_ERR (at 0x3607)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STATUS                                   = " "0, 1"
    tree.end
    tree "TADC_INT_RT_STS"
      sgroup "TADC_INT_RT_STS (at 0x3610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (EOC_INT_FALSE),1 (EOC_INT_TRUE)"
    tree.end
    tree "TADC_INT_SET_TYPE"
      sgroup "TADC_INT_SET_TYPE (at 0x3611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_INT_LEVEL_TRIGGERED),1 (EOC_INT_EDGE_TRIGGERED)"
    tree.end
    tree "TADC_INT_POLARITY_HIGH"
      sgroup "TADC_INT_POLARITY_HIGH (at 0x3612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_RISING_EDGE_TRIGGER_DISABL),1 (EOC_INT_RISING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "TADC_INT_POLARITY_LOW"
      sgroup "TADC_INT_POLARITY_LOW (at 0x3613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_FALLING_EDGE_TRIGGER_DISABL),1 (EOC_INT_FALLING_EDGE_TRIGGER_ENABL)"
    tree.end
    tree "TADC_INT_LATCHED_CLR"
      sgroup "TADC_INT_LATCHED_CLR (at 0x3614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "TADC_INT_EN_SET"
      sgroup "TADC_INT_EN_SET (at 0x3615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLE),1 (EOC_INT_ENABLE)"
    tree.end
    tree "TADC_INT_EN_CLR"
      sgroup "TADC_INT_EN_CLR (at 0x3616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLE),1 (EOC_INT_ENABLE)"
    tree.end
    tree "TADC_INT_LATCHED_STS"
      sgroup "TADC_INT_LATCHED_STS (at 0x3618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_NOT_TRIGGERED),1 (EOC_INT_TRIGGERED_AND_LATCHED)"
    tree.end
    tree "TADC_INT_PENDING_STS"
      sgroup "TADC_INT_PENDING_STS (at 0x3619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_NOT_PENDING),1 (EOC_INT_PENDING)"
    tree.end
    tree "TADC_INT_MID_SEL"
      sgroup "TADC_INT_MID_SEL (at 0x361a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80361a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x361a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID_0),1 (MID_1),2 (MID_2),3 (MID_3)"
    tree.end
    tree "TADC_INT_PRIORITY"
      sgroup "TADC_INT_PRIORITY (at 0x361b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x80361b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x361b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (INT_PRIORITY_SR_0),1 (INT_PRIORITY_A_1)"
    tree.end
    tree "TADC_EN_CTL"
      sgroup "TADC_EN_CTL (at 0x3646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TADC_EN                                  = " "0 (TADC_DISABLE),1 (TADC_ENABLE)"
    tree.end
    tree "TADC_CONV_REQ"
      sgroup "TADC_CONV_REQ (at 0x3651)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CMD                                      = "
    tree.end
    tree "TADC_HWTRIG_CONV_CH_EN"
      sgroup "TADC_HWTRIG_CONV_CH_EN (at 0x3652)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CMD                                      = "
    tree.end
    tree "TADC_HW_SETTLE_DELAY"
      sgroup "TADC_HW_SETTLE_DELAY (at 0x3653)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "TADC_LONG_HW_SETTLE_DLY_EN"
      sgroup "TADC_LONG_HW_SETTLE_DLY_EN (at 0x3654)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "TADC_LONG_HW_SETTLE_DLY"
      sgroup "TADC_LONG_HW_SETTLE_DLY (at 0x3655)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SEL                                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_ADC_BUF_CH"
      sgroup "TADC_ADC_BUF_CH (at 0x3656)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "TADC_ADC_AAF_CH"
      sgroup "TADC_ADC_AAF_CH (at 0x3657)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "TADC_ADC_DATA_RDBK"
      sgroup "TADC_ADC_DATA_RDBK (at 0x3658)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CTL                                      = " "0, 1"
    tree.end
    tree "TADC_CH1_ADC_LO"
      sgroup "TADC_CH1_ADC_LO (at 0x3660)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH1_ADC_HI"
      sgroup "TADC_CH1_ADC_HI (at 0x3661)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH2_ADC_LO"
      sgroup "TADC_CH2_ADC_LO (at 0x3662)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH2_ADC_HI"
      sgroup "TADC_CH2_ADC_HI (at 0x3663)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH3_ADC_LO"
      sgroup "TADC_CH3_ADC_LO (at 0x3664)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH3_ADC_HI"
      sgroup "TADC_CH3_ADC_HI (at 0x3665)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH4_ADC_LO"
      sgroup "TADC_CH4_ADC_LO (at 0x3666)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH4_ADC_HI"
      sgroup "TADC_CH4_ADC_HI (at 0x3667)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH5_ADC_LO"
      sgroup "TADC_CH5_ADC_LO (at 0x3668)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH5_ADC_HI"
      sgroup "TADC_CH5_ADC_HI (at 0x3669)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH6_ADC_LO"
      sgroup "TADC_CH6_ADC_LO (at 0x3670)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH6_ADC_HI"
      sgroup "TADC_CH6_ADC_HI (at 0x3671)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH7_ADC_LO"
      sgroup "TADC_CH7_ADC_LO (at 0x3672)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH7_ADC_HI"
      sgroup "TADC_CH7_ADC_HI (at 0x3673)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH8_ADC_LO"
      sgroup "TADC_CH8_ADC_LO (at 0x3674)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CH8_ADC_HI"
      sgroup "TADC_CH8_ADC_HI (at 0x3675)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_SEC_ACCESS"
      sgroup "TADC_SEC_ACCESS (at 0x36d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TADC_PERPH_RESET_CTL1"
      sgroup "TADC_PERPH_RESET_CTL1 (at 0x36d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (ENABLE_PRESET_FALSE),1 (ENABLE_PRESET_TRUE)"
    tree.end
    tree "TADC_PERPH_RESET_CTL2"
      sgroup "TADC_PERPH_RESET_CTL2 (at 0x36d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "TADC_PERPH_RESET_CTL3"
      sgroup "TADC_PERPH_RESET_CTL3 (at 0x36da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TADC_PERPH_RESET_CTL4"
      sgroup "TADC_PERPH_RESET_CTL4 (at 0x36db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "TADC_INT_TEST1"
      sgroup "TADC_INT_TEST1 (at 0x36e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_EN_FALSE),1 (INT_TEST_MODE_EN_TRUE)"
    tree.end
    tree "TADC_INT_TEST_VAL"
      sgroup "TADC_INT_TEST_VAL (at 0x36e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_INT_TEST_VAL_0),1 (EOC_INT_TEST_VAL_1)"
    tree.end
    tree "TADC_HW_CH_CONV"
      sgroup "TADC_HW_CH_CONV (at 0x36e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
    tree "TADC_ATEST"
      sgroup "TADC_ATEST (at 0x36e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TADC_ATEST2                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TADC_ATEST1                              = "
    tree.end
    tree "TADC_DTEST"
      sgroup "TADC_DTEST (at 0x36e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TADC_ADCTEST1"
      sgroup "TADC_ADCTEST1 (at 0x36e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLKMODE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADCTEST1_SEL                             = " "0 (ADCTEST1_NORMAL),1 (ADCTEST1_FORCE_ON),2 (ADCTEST1_TBD2),3 (ADCTEST1_CLK_NOCHOP),4 (ADCTEST1_CLKZ_NOCHOP),5 (ADCTEST1_VCMN_VAADIV2),6 (ADCTEST1_COMPB_DIG_ONLY),7 (ADCTEST1_IN_VREF)"
    tree.end
    tree "TADC_ADC_DIRECT_TST"
      sgroup "TADC_ADC_DIRECT_TST (at 0x36e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CHSEL                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SDMRST                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONVREQ                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SKINTMP_OR_THERM2_B                      = " "0, 1"
    tree.end
    tree "TADC_TRIM_NUM"
      sgroup "TADC_TRIM_NUM (at 0x36f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "TADC_TRIM_VREFP"
      sgroup "TADC_TRIM_VREFP (at 0x36f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VREFP_TRIM                               = "
    tree.end
    tree "TADC_TRIM_VIN_SCALER"
      sgroup "TADC_TRIM_VIN_SCALER (at 0x36f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VINSCALER_TRIM                           = "
    tree.end
    tree "TADC_TRIM_BIAS_SCALER"
      sgroup "TADC_TRIM_BIAS_SCALER (at 0x36f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BIAS_SCALER_TRIM                         = "
    tree.end
    tree "TADC_TRIM_OFF_REFP"
      sgroup "TADC_TRIM_OFF_REFP (at 0x36f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFST_REFP_TRIM                          = "
    tree.end
    tree "TADC_TRIM_OFF_BIAS"
      sgroup "TADC_TRIM_OFF_BIAS (at 0x36f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFST_BIAS_TRIM                          = "
    tree.end
    tree "TADC_TRIM_OFF_VINSCL"
      sgroup "TADC_TRIM_OFF_VINSCL (at 0x36f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFST_VINSCL_TRIM                        = "
    tree.end
    tree "TADC_TRIM_ANA"
      sgroup "TADC_TRIM_ANA (at 0x36f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        set &access:&cmd_addr %l 0x8036f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x36f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   NTCSIG_TRIM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SIGSUPPLY_TRIM                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CMN_TRIM                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NTCREF_TRIM                              = " "0, 1"
    tree.end
  tree.end
tree.end
tree "TADC_CMP"
  tree "TADC_CMP"
    tree "TADC_CMP_REVISION1"
      sgroup "TADC_CMP_REVISION1 (at 0x3700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TADC_CMP_REVISION2"
      sgroup "TADC_CMP_REVISION2 (at 0x3701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TADC_CMP_PERPH_TYPE"
      sgroup "TADC_CMP_PERPH_TYPE (at 0x3704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TADC_CMP_PERPH_SUBTYPE"
      sgroup "TADC_CMP_PERPH_SUBTYPE (at 0x3705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TADC_CMP_THR1_CMP"
      sgroup "TADC_CMP_THR1_CMP (at 0x3751)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "TADC_CMP_THR1_CH1_CMP_LO"
      sgroup "TADC_CMP_THR1_CH1_CMP_LO (at 0x3752)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR1_CH1_CMP_HI"
      sgroup "TADC_CMP_THR1_CH1_CMP_HI (at 0x3753)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR1_CH2_CMP_LO"
      sgroup "TADC_CMP_THR1_CH2_CMP_LO (at 0x3754)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR1_CH2_CMP_HI"
      sgroup "TADC_CMP_THR1_CH2_CMP_HI (at 0x3755)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR1_CH3_CMP_LO"
      sgroup "TADC_CMP_THR1_CH3_CMP_LO (at 0x3756)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR1_CH3_CMP_HI"
      sgroup "TADC_CMP_THR1_CH3_CMP_HI (at 0x3757)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR2_CMP"
      sgroup "TADC_CMP_THR2_CMP (at 0x3767)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "TADC_CMP_THR2_CH1_CMP_LO"
      sgroup "TADC_CMP_THR2_CH1_CMP_LO (at 0x3768)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR2_CH1_CMP_HI"
      sgroup "TADC_CMP_THR2_CH1_CMP_HI (at 0x3769)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR2_CH2_CMP_LO"
      sgroup "TADC_CMP_THR2_CH2_CMP_LO (at 0x376a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80376a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x376a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR2_CH2_CMP_HI"
      sgroup "TADC_CMP_THR2_CH2_CMP_HI (at 0x376b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80376b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x376b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR2_CH3_CMP_LO"
      sgroup "TADC_CMP_THR2_CH3_CMP_LO (at 0x376c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80376c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x376c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR2_CH3_CMP_HI"
      sgroup "TADC_CMP_THR2_CH3_CMP_HI (at 0x376d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80376d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x376d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR3_CMP"
      sgroup "TADC_CMP_THR3_CMP (at 0x377d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80377d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x377d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "TADC_CMP_THR3_CH1_CMP_LO"
      sgroup "TADC_CMP_THR3_CH1_CMP_LO (at 0x377e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80377e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x377e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR3_CH1_CMP_HI"
      sgroup "TADC_CMP_THR3_CH1_CMP_HI (at 0x377f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x80377f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x377f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR3_CH2_CMP_LO"
      sgroup "TADC_CMP_THR3_CH2_CMP_LO (at 0x3780)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR3_CH2_CMP_HI"
      sgroup "TADC_CMP_THR3_CH2_CMP_HI (at 0x3781)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR3_CH3_CMP_LO"
      sgroup "TADC_CMP_THR3_CH3_CMP_LO (at 0x3782)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR3_CH3_CMP_HI"
      sgroup "TADC_CMP_THR3_CH3_CMP_HI (at 0x3783)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037830
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37830
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR4_CMP"
      sgroup "TADC_CMP_THR4_CMP (at 0x3793)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CTL                                      = "
    tree.end
    tree "TADC_CMP_THR4_CH1_CMP_LO"
      sgroup "TADC_CMP_THR4_CH1_CMP_LO (at 0x3794)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR4_CH1_CMP_HI"
      sgroup "TADC_CMP_THR4_CH1_CMP_HI (at 0x3795)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DATA                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "TADC_CMP_THR1_CH1_HYST"
      sgroup "TADC_CMP_THR1_CH1_HYST (at 0x37b0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR2_CH1_HYST"
      sgroup "TADC_CMP_THR2_CH1_HYST (at 0x37b1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR3_CH1_HYST"
      sgroup "TADC_CMP_THR3_CH1_HYST (at 0x37b2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_THR4_CH1_HYST"
      sgroup "TADC_CMP_THR4_CH1_HYST (at 0x37b3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   DATA                                     = "
    tree.end
    tree "TADC_CMP_SEC_ACCESS"
      sgroup "TADC_CMP_SEC_ACCESS (at 0x37d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TADC_CMP_PERPH_RESET_CTL2"
      sgroup "TADC_CMP_PERPH_RESET_CTL2 (at 0x37d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "TADC_CMP_PERPH_RESET_CTL3"
      sgroup "TADC_CMP_PERPH_RESET_CTL3 (at 0x37da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TADC_CMP_PERPH_RESET_CTL4"
      sgroup "TADC_CMP_PERPH_RESET_CTL4 (at 0x37db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "TADC_CMP_CMP_THR1"
      sgroup "TADC_CMP_CMP_THR1 (at 0x37e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
    tree "TADC_CMP_CMP_THR2"
      sgroup "TADC_CMP_CMP_THR2 (at 0x37e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
    tree "TADC_CMP_CMP_THR3"
      sgroup "TADC_CMP_CMP_THR3 (at 0x37e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
    tree "TADC_CMP_CMP_THR4"
      sgroup "TADC_CMP_CMP_THR4 (at 0x37e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        set &access:&cmd_addr %l 0x8037e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x37e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   STATUS                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80feda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end

