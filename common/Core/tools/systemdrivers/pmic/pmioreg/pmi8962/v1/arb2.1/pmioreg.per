      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LATCHED_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LATCHED_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LATCHED_CLR             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_EN_SET"
      sgroup "SMBCHG_BAT_IF_INT_EN_SET (at 0x1215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_EN_SET                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_EN_SET                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_EN_SET                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_EN_SET                  = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_EN_CLR"
      sgroup "SMBCHG_BAT_IF_INT_EN_CLR (at 0x1216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_EN_CLR                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_EN_CLR                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_EN_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_EN_CLR                  = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_LATCHED_STS"
      sgroup "SMBCHG_BAT_IF_INT_LATCHED_STS (at 0x1218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_LATCHED_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_LATCHED_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_LATCHED_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_LATCHED_STS             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_PENDING_STS"
      sgroup "SMBCHG_BAT_IF_INT_PENDING_STS (at 0x1219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_PENDING_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_PENDING_STS                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_PENDING_STS                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_PENDNG_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_PENDING_STS             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_MID_SEL"
      sgroup "SMBCHG_BAT_IF_INT_MID_SEL (at 0x121a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_INT_PRIORITY"
      sgroup "SMBCHG_BAT_IF_INT_PRIORITY (at 0x121b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x80121b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x121b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_SHIP_MODE"
      sgroup "SMBCHG_BAT_IF_SHIP_MODE (at 0x1240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SHIP_MODE_ENB                            = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_CLR_DEAD_BAT_TIMER"
      sgroup "SMBCHG_BAT_IF_CLR_DEAD_BAT_TIMER (at 0x1241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CLR_DEAD_BAT_TIMER                       = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_CMD_CHG"
      sgroup "SMBCHG_BAT_IF_CMD_CHG (at 0x1242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WIRELESS_CHG_DIS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   THERM_NTC_I_OVERRIDE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   STAT_OUTPUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FC_COM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   EN_BAT_CHG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OTG_EN                                   = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_SEC_ACCESS"
      sgroup "SMBCHG_BAT_IF_SEC_ACCESS (at 0x12d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_BAT_IF_PERPH_RESET_CTL2"
      sgroup "SMBCHG_BAT_IF_PERPH_RESET_CTL2 (at 0x12d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_PERPH_RESET_CTL3"
      sgroup "SMBCHG_BAT_IF_PERPH_RESET_CTL3 (at 0x12da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_PERPH_RESET_CTL4"
      sgroup "SMBCHG_BAT_IF_PERPH_RESET_CTL4 (at 0x12db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_SPARE"
      sgroup "SMBCHG_BAT_IF_SPARE (at 0x12df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_BAT_IF_INT_TEST1"
      sgroup "SMBCHG_BAT_IF_INT_TEST1 (at 0x12e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_INT_TEST_VAL"
      sgroup "SMBCHG_BAT_IF_INT_TEST_VAL (at 0x12e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TERM_MISSING_INT_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_MISSING_INT_VAL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LOW_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_INT_VAL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   COLD_BAT_SOFT_LIM_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_BAT_HARD_LIM_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_BAT_SOFT_LIM_INT_VAL                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOT_BAT_HARD_LIM_INT_VAL                 = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_TRIM_NUM"
      sgroup "SMBCHG_BAT_IF_TRIM_NUM (at 0x12f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_BAT_IF_VBL_CFG"
      sgroup "SMBCHG_BAT_IF_VBL_CFG (at 0x12f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LOW_BAT_THRESHOLD                        = "
    tree.end
    tree "SMBCHG_BAT_IF_VBL_SEL_CFG"
      sgroup "SMBCHG_BAT_IF_VBL_SEL_CFG (at 0x12f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VBAT_LOW_STATE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   VBAT_LOW_SRC                             = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_BM_CFG"
      sgroup "SMBCHG_BAT_IF_BM_CFG (at 0x12f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_FET_CFG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_MISSING_INPUT_PLUGIN                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   BAT_MISSING_2S6_POLLER                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BAT_MISSING_ALGORITHM                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BAT_MISSING_PIN_SRC                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_CFG_SYSMIN"
      sgroup "SMBCHG_BAT_IF_CFG_SYSMIN (at 0x12f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SYSMIN                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_CFG_SYSTH"
      sgroup "SMBCHG_BAT_IF_CFG_SYSTH (at 0x12f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_SYSTH                                = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_SS_CFG"
      sgroup "SMBCHG_BAT_IF_SS_CFG (at 0x12f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_NO_SS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_SS_SEL                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_TRIM7"
      sgroup "SMBCHG_BAT_IF_TRIM7 (at 0x12f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_TLLS                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFG_CLK2MHZ                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_EN_FREQFOLD                          = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_CFG_BB_CLMP_SEL"
      sgroup "SMBCHG_BAT_IF_CFG_BB_CLMP_SEL (at 0x12f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_BB_CLMP_SEL                          = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_BAT_IF_TRIM9"
      sgroup "SMBCHG_BAT_IF_TRIM9 (at 0x12f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_EN_OS_ZD                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CFG_ENB_SC                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CFG_HI_BW                                = "
    tree.end
    tree "SMBCHG_BAT_IF_ISENSE_CFG1"
      sgroup "SMBCHG_BAT_IF_ISENSE_CFG1 (at 0x12fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   ISENSE_DCHG_G                            = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_DCHG_TEMP                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_BAT_IF_ISENSE_CFG2"
      sgroup "SMBCHG_BAT_IF_ISENSE_CFG2 (at 0x12fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   ISENSE_CHG_G                             = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ISENSE_CHG_TEMP                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_BAT_IF_CFG_EN_100M"
      sgroup "SMBCHG_BAT_IF_CFG_EN_100M (at 0x12fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_EN_100M                              = " "0, 1"
    tree.end
    tree "SMBCHG_BAT_IF_BMD_RMV_CFG"
      sgroup "SMBCHG_BAT_IF_BMD_RMV_CFG (at 0x12fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        set &access:&cmd_addr %l 0x8012fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x12fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BMD_RMV_CFG                              = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "SMBCHG_CHGR"
  tree "SMBCHG_CHGR"
    tree "SMBCHG_CHGR_PERPH_TYPE"
      sgroup "SMBCHG_CHGR_PERPH_TYPE (at 0x1004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_CHGR_PERPH_SUBTYPE"
      sgroup "SMBCHG_CHGR_PERPH_SUBTYPE (at 0x1005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_CHGR_CHG_OPTION"
      sgroup "SMBCHG_CHGR_CHG_OPTION (at 0x1008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PIN                                      = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_VBAT_STATUS"
      sgroup "SMBCHG_CHGR_VBAT_STATUS (at 0x100b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ABOVE_VBAT_WEAK                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_FV_STS"
      sgroup "SMBCHG_CHGR_FV_STS (at 0x100c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_STS                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV_STS                                   = "
    tree.end
    tree "SMBCHG_CHGR_ICHG_STS"
      sgroup "SMBCHG_CHGR_ICHG_STS (at 0x100d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   PCC_STS                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FCC_STS                                  = "
    tree.end
    tree "SMBCHG_CHGR_CHGR_STS"
      sgroup "SMBCHG_CHGR_CHGR_STS (at 0x100e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80100e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x100e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_I_STS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_FV_COMP_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DONE_STS                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BATV_LT_2V                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HOLD_OFF_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   CHARGING_STS                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHG_EN                                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_RT_STS"
      sgroup "SMBCHG_CHGR_INT_RT_STS (at 0x1010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_RT_STS           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_RT_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_RT_STS          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_RT_STS             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_RT_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_RT_STS                        = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_SET_TYPE"
      sgroup "SMBCHG_CHGR_INT_SET_TYPE (at 0x1011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_TYPE             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_TYPE              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_TYPE            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_TYPE               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_TYPE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_TYPE                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_POLARITY_HIGH"
      sgroup "SMBCHG_CHGR_INT_POLARITY_HIGH (at 0x1012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_HIGH             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_HIGH              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_HIGH            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_HIGH               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_HIGH                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_HIGH                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_POLARITY_LOW"
      sgroup "SMBCHG_CHGR_INT_POLARITY_LOW (at 0x1013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LOW              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LOW               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LOW             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LOW                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LOW                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LOW                           = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_LATCHED_CLR"
      sgroup "SMBCHG_CHGR_INT_LATCHED_CLR (at 0x1014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LATCHED_CLR      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LATCHED_CLR       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LATCHED_CLR     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LATCHED_CLR        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_EN_SET"
      sgroup "SMBCHG_CHGR_INT_EN_SET (at 0x1015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_EN_SET           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_EN_SET            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_EN_SET          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_EN_SET             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_EN_SET                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_SET                        = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_EN_CLR"
      sgroup "SMBCHG_CHGR_INT_EN_CLR (at 0x1016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_EN_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_EN_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_EN_CLR          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_EN_CLR             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_EN_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_EN_CLR                        = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_LATCHED_STS"
      sgroup "SMBCHG_CHGR_INT_LATCHED_STS (at 0x1018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_LATCHED_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_LATCHED_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_LATCHED_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_LATCHED_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_LATCHED_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_PENDING_STS"
      sgroup "SMBCHG_CHGR_INT_PENDING_STS (at 0x1019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_PENDING_STS      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_PENDING_STS       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_PENDING_STS     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_PENDING_STS        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_PENDING_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_PENDING_STS                   = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_MID_SEL"
      sgroup "SMBCHG_CHGR_INT_MID_SEL (at 0x101a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_CHGR_INT_PRIORITY"
      sgroup "SMBCHG_CHGR_INT_PRIORITY (at 0x101b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_SEC_ACCESS"
      sgroup "SMBCHG_CHGR_SEC_ACCESS (at 0x10d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_CHGR_PERPH_RESET_CTL2"
      sgroup "SMBCHG_CHGR_PERPH_RESET_CTL2 (at 0x10d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_PERPH_RESET_CTL3"
      sgroup "SMBCHG_CHGR_PERPH_RESET_CTL3 (at 0x10da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_PERPH_RESET_CTL4"
      sgroup "SMBCHG_CHGR_PERPH_RESET_CTL4 (at 0x10db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_SPARE"
      sgroup "SMBCHG_CHGR_SPARE (at 0x10df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_CHGR_INT_TEST1"
      sgroup "SMBCHG_CHGR_INT_TEST1 (at 0x10e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_INT_TEST_VAL"
      sgroup "SMBCHG_CHGR_INT_TEST_VAL (at 0x10e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BAT_TCC_REACHED_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   BAT_TAPER_MODE_CHARGING_INT_VAL          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_LT_RECHG_THRESHOLD_INT_VAL           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_FT_P2F_CHG_THRESHOLD_INT_VAL         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHGR_COMPLETE_CHG_SFT_INT_VAL            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CHGR_PRECHG_SFT_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CHGR_INHIBIT_INT_VAL                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHGR_ERROR_INT_VAL                       = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE1"
      sgroup "SMBCHG_CHGR_TEST_MODE1 (at 0x10e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TM_CHG_7_0                               = "
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE2"
      sgroup "SMBCHG_CHGR_TEST_MODE2 (at 0x10e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TM_CHG_12_8                              = "
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE3"
      sgroup "SMBCHG_CHGR_TEST_MODE3 (at 0x10e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TM_TLOOP                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_NGATE                                 = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_TEST_MODE4"
      sgroup "SMBCHG_CHGR_TEST_MODE4 (at 0x10e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_START_COPY                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_TEST_15_8"
      sgroup "SMBCHG_CHGR_TEST_15_8 (at 0x10e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_15_8                                = "
    tree.end
    tree "SMBCHG_CHGR_TEST_7_0"
      sgroup "SMBCHG_CHGR_TEST_7_0 (at 0x10e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_7_0                                 = "
    tree.end
    tree "SMBCHG_CHGR_TRIM_NUM"
      sgroup "SMBCHG_CHGR_TRIM_NUM (at 0x10f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_CHGR_PCC_CFG"
      sgroup "SMBCHG_CHGR_PCC_CFG (at 0x10f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PCC                                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_CHGR_FCC_CFG"
      sgroup "SMBCHG_CHGR_FCC_CFG (at 0x10f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   FCC                                      = "
    tree.end
    tree "SMBCHG_CHGR_FCC_CMP_CFG"
      sgroup "SMBCHG_CHGR_FCC_CMP_CFG (at 0x10f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FCC_COMP                                 = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_CHGR_FV_CFG"
      sgroup "SMBCHG_CHGR_FV_CFG (at 0x10f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV                                       = "
    tree.end
    tree "SMBCHG_CHGR_FV_CMP_CFG"
      sgroup "SMBCHG_CHGR_FV_CMP_CFG (at 0x10f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   FV_COMP                                  = "
    tree.end
    tree "SMBCHG_CHGR_CFG_AFVC"
      sgroup "SMBCHG_CHGR_CFG_AFVC (at 0x10f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CHGR_AUTO_FV_COMP                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_CHGR_CFG_CHG_INHIB"
      sgroup "SMBCHG_CHGR_CFG_CHG_INHIB (at 0x10f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CHGR_INHIBIT_THRESHOLD                   = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_CHGR_CFG_P2F"
      sgroup "SMBCHG_CHGR_CFG_P2F (at 0x10f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P2F_CHG_THRESHOLD                        = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_CHGR_CFG_TCC"
      sgroup "SMBCHG_CHGR_CFG_TCC (at 0x10f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CHG_TERM_I                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_CHGR_CCMP_CFG"
      sgroup "SMBCHG_CHGR_CCMP_CFG (at 0x10fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TEMP_MONITOR_ENABLE                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   JEITA_TEMP_HARD_LIMIT                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOAD_BAT                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HOT_SL_FV_COMP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COLD_SL_FV_COMP                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOT_SL_CHG_I_COMP                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   COLD_SL_CHG_I_COMP                       = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_CHGR_CFG1"
      sgroup "SMBCHG_CHGR_CHGR_CFG1 (at 0x10fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SYSOK_INOK_POL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   SYSOK_OPTIONS                            = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   EARLY_TERM_STATUS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TERM_I_SRC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RECHG_THRESHOLD_SRC                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGING_HOLDOFF                         = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_CHGR_CFG2"
      sgroup "SMBCHG_CHGR_CHGR_CFG2 (at 0x10fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_EN_SRC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CHG_EN_COMMAND                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   P2F_CHG_TRAN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   BAT_OV_ECC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   I_TERM                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AUTO_RECHG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HOLD_OFF_TIMER_CHARGING                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CHARGER_INHIBIT                          = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_SFT_CFG"
      sgroup "SMBCHG_CHGR_SFT_CFG (at 0x10fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SFT_EN                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   SFT_TIMEOUT                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PRE_CHG_SFT_TIMEOUT                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_CHGR_STAT_CFG"
      sgroup "SMBCHG_CHGR_STAT_CFG (at 0x10fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   STAT_PIN_CONFIG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TEMP_CHG_ERROR_BLINKING_EN               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STAT_PIN_SRC                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STAT_PIN_OUTPUT_POL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STAT_PIN_OUTPUT_EN                       = " "0, 1"
    tree.end
    tree "SMBCHG_CHGR_CFG"
      sgroup "SMBCHG_CHGR_CFG (at 0x10ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CHG_OPTION_PIN_TRIM                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CFG_VCHG_IIN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CFG_TAPER_DIS_AFVC                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CFG_VCHG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_RCHG_LVL                             = " "0, 1"
    tree.end
  tree.end
tree.end
tree "SMBCHG_DC_CHGPTH"
  tree "SMBCHG_DC_CHGPTH"
    tree "SMBCHG_DC_CHGPTH_PERPH_TYPE"
      sgroup "SMBCHG_DC_CHGPTH_PERPH_TYPE (at 0x1404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_SUBTYPE"
      sgroup "SMBCHG_DC_CHGPTH_PERPH_SUBTYPE (at 0x1405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_RT_STS"
      sgroup "SMBCHG_DC_CHGPTH_INT_RT_STS (at 0x1410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_RT_STS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_RT_STS                           = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_SET_TYPE"
      sgroup "SMBCHG_DC_CHGPTH_INT_SET_TYPE (at 0x1411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_TYPE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_TYPE                             = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_POLARITY_HIGH"
      sgroup "SMBCHG_DC_CHGPTH_INT_POLARITY_HIGH (at 0x1412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_HIGH                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_HIGH                             = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_POLARITY_LOW"
      sgroup "SMBCHG_DC_CHGPTH_INT_POLARITY_LOW (at 0x1413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LOW                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LOW                              = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_LATCHED_CLR"
      sgroup "SMBCHG_DC_CHGPTH_INT_LATCHED_CLR (at 0x1414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LATCHED_CLR                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_EN_SET"
      sgroup "SMBCHG_DC_CHGPTH_INT_EN_SET (at 0x1415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_EN_SET                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_EN_SET                           = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_EN_CLR"
      sgroup "SMBCHG_DC_CHGPTH_INT_EN_CLR (at 0x1416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_EN_CLR                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_EN_CLR                           = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_LATCHED_STS"
      sgroup "SMBCHG_DC_CHGPTH_INT_LATCHED_STS (at 0x1418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_LATCHED_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_LATCHED_STS                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_PENDING_STS"
      sgroup "SMBCHG_DC_CHGPTH_INT_PENDING_STS (at 0x1419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_PENDING_STS                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_PENDING_STS                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_MID_SEL"
      sgroup "SMBCHG_DC_CHGPTH_INT_MID_SEL (at 0x141a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_PRIORITY"
      sgroup "SMBCHG_DC_CHGPTH_INT_PRIORITY (at 0x141b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_SEC_ACCESS"
      sgroup "SMBCHG_DC_CHGPTH_SEC_ACCESS (at 0x14d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL2"
      sgroup "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL2 (at 0x14d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL3"
      sgroup "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL3 (at 0x14da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL4"
      sgroup "SMBCHG_DC_CHGPTH_PERPH_RESET_CTL4 (at 0x14db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_SPARE"
      sgroup "SMBCHG_DC_CHGPTH_SPARE (at 0x14df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_TEST1"
      sgroup "SMBCHG_DC_CHGPTH_INT_TEST1 (at 0x14e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_INT_TEST_VAL"
      sgroup "SMBCHG_DC_CHGPTH_INT_TEST_VAL (at 0x14e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DCIN_OV_INT_VAL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_UV_INT_VAL                          = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TM_EN_ATEST_DCIN"
      sgroup "SMBCHG_DC_CHGPTH_TM_EN_ATEST_DCIN (at 0x14e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_EN_ATEST_DCIN                         = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM_NUM"
      sgroup "SMBCHG_DC_CHGPTH_TRIM_NUM (at 0x14f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_DCIN_CHGR_CFG"
      sgroup "SMBCHG_DC_CHGPTH_DCIN_CHGR_CFG (at 0x14f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADAPTER_ALLOWANCE                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_DC_CHGPTH_DCIN_IL_CFG"
      sgroup "SMBCHG_DC_CHGPTH_DCIN_IL_CFG (at 0x14f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CURRENT_LIMIT                            = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_DC_AICL_CFG1"
      sgroup "SMBCHG_DC_CHGPTH_DC_AICL_CFG1 (at 0x14f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OV_OPTION                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_9V_ADAPTER_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEB_9V_ADAPTER_SEL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEB_5V_ADAPTER_SEL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEB_HV_ADAPTER                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEB_LV_ADAPTER                           = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_DC_AICL_CFG2"
      sgroup "SMBCHG_DC_CHGPTH_DC_AICL_CFG2 (at 0x14f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DEB_UV                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AICL_THRESHOLD_5V_TO_9V                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AICL_THRESHOLD_5V                        = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_AICL_WL_SEL_CFG"
      sgroup "SMBCHG_DC_CHGPTH_AICL_WL_SEL_CFG (at 0x14f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   AICL_RESTART_TIMER                       = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TEMP_COMP_CFG"
      sgroup "SMBCHG_DC_CHGPTH_TEMP_COMP_CFG (at 0x14f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CFG_EN_TLOOP                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_DIS_TLOOP                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CFG_DIS_DIG_TLOOP                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   INT_TEMP_COMP_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   INT_TEMP_COMP_SETTING                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_TEMP_COMP_CYCLE_TIME                 = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM7"
      sgroup "SMBCHG_DC_CHGPTH_TRIM7 (at 0x14f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_80R32B                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_LORAMP                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_LONG_REFRESH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_GAIN1X                                = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM8"
      sgroup "SMBCHG_DC_CHGPTH_TRIM8 (at 0x14f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TR_SCTR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   TR_OSC3M                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_OSC2M                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM9"
      sgroup "SMBCHG_DC_CHGPTH_TRIM9 (at 0x14f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_DUTY                                  = "
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   TR_ZDTR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_BLTR                                  = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_TEMP"
      sgroup "SMBCHG_DC_CHGPTH_TR_TEMP (at 0x14fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_TEMP                                  = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM11"
      sgroup "SMBCHG_DC_CHGPTH_TRIM11 (at 0x14fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TR_HICAP_VMODE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_SOFT                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_BT                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_DIS_SSUD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_NEW_TRIM                              = " "0, 1"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TRIM12"
      sgroup "SMBCHG_DC_CHGPTH_TRIM12 (at 0x14fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_VD                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_VDTHRES                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_DCIN_SNS"
      sgroup "SMBCHG_DC_CHGPTH_TR_DCIN_SNS (at 0x14fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_DCIN_SNS                              = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_DCIN_DIVIDER"
      sgroup "SMBCHG_DC_CHGPTH_TR_DCIN_DIVIDER (at 0x14fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_DCIN_DIVIDER                          = "
    tree.end
    tree "SMBCHG_DC_CHGPTH_TR_IINOS_DC"
      sgroup "SMBCHG_DC_CHGPTH_TR_IINOS_DC (at 0x14ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IINOS_DC                              = "
    tree.end
  tree.end
tree.end
tree "SMBCHG_MISC"
  tree "SMBCHG_MISC"
    tree "SMBCHG_MISC_REVISION1"
      sgroup "SMBCHG_MISC_REVISION1 (at 0x1600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SMBCHG_MISC_REVISION2"
      sgroup "SMBCHG_MISC_REVISION2 (at 0x1601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SMBCHG_MISC_REVISION3"
      sgroup "SMBCHG_MISC_REVISION3 (at 0x1602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SMBCHG_MISC_REVISION4"
      sgroup "SMBCHG_MISC_REVISION4 (at 0x1603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SMBCHG_MISC_PERPH_TYPE"
      sgroup "SMBCHG_MISC_PERPH_TYPE (at 0x1604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_MISC_PERPH_SUBTYPE"
      sgroup "SMBCHG_MISC_PERPH_SUBTYPE (at 0x1605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_MISC_IDEV_STS"
      sgroup "SMBCHG_MISC_IDEV_STS (at 0x1608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SRC_DETECT_STS                           = "
    tree.end
    tree "SMBCHG_MISC_INT_RT_STS"
      sgroup "SMBCHG_MISC_INT_RT_STS (at 0x1610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_RT_STS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_RT_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_RT_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_RT_STS                          = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_SET_TYPE"
      sgroup "SMBCHG_MISC_INT_SET_TYPE (at 0x1611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_TYPE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_TYPE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_TYPE                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_TYPE                            = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_POLARITY_HIGH"
      sgroup "SMBCHG_MISC_INT_POLARITY_HIGH (at 0x1612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_HIGH                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_HIGH                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_HIGH                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_HIGH                            = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_POLARITY_LOW"
      sgroup "SMBCHG_MISC_INT_POLARITY_LOW (at 0x1613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LOW                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LOW                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LOW                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LOW                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_LATCHED_CLR"
      sgroup "SMBCHG_MISC_INT_LATCHED_CLR (at 0x1614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LATCHED_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LATCHED_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LATCHED_CLR                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_EN_SET"
      sgroup "SMBCHG_MISC_INT_EN_SET (at 0x1615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_EN_SET                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_EN_SET                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_EN_SET                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_EN_SET                          = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_EN_CLR"
      sgroup "SMBCHG_MISC_INT_EN_CLR (at 0x1616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_EN_CLR                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_EN_CLR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_EN_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_LATCHED_STS"
      sgroup "SMBCHG_MISC_INT_LATCHED_STS (at 0x1618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_LATCHED_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_LATCHED_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_LATCHED_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_PENDING_STS"
      sgroup "SMBCHG_MISC_INT_PENDING_STS (at 0x1619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_PENDING_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_PENDING_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_PENDING_STS                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_MID_SEL"
      sgroup "SMBCHG_MISC_INT_MID_SEL (at 0x161a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_MISC_INT_PRIORITY"
      sgroup "SMBCHG_MISC_INT_PRIORITY (at 0x161b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x80161b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x161b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_WDOG_RST"
      sgroup "SMBCHG_MISC_WDOG_RST (at 0x1640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   WDOG_RST                                 = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_AFP_MODE"
      sgroup "SMBCHG_MISC_AFP_MODE (at 0x1641)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFP_MODE_ENB                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_GSM_PA_ON_ADJ_EN"
      sgroup "SMBCHG_MISC_GSM_PA_ON_ADJ_EN (at 0x1642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GSM_PA_ON_ADJ_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_SEC_ACCESS"
      sgroup "SMBCHG_MISC_SEC_ACCESS (at 0x16d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_MISC_PERPH_RESET_CTL2"
      sgroup "SMBCHG_MISC_PERPH_RESET_CTL2 (at 0x16d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_PERPH_RESET_CTL3"
      sgroup "SMBCHG_MISC_PERPH_RESET_CTL3 (at 0x16da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_PERPH_RESET_CTL4"
      sgroup "SMBCHG_MISC_PERPH_RESET_CTL4 (at 0x16db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_SPARE"
      sgroup "SMBCHG_MISC_SPARE (at 0x16df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_MISC_INT_TEST1"
      sgroup "SMBCHG_MISC_INT_TEST1 (at 0x16e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_INT_TEST_VAL"
      sgroup "SMBCHG_MISC_INT_TEST_VAL (at 0x16e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OTST3_INT_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTST2_INT_VAL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FLASH_FAIL_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_TIMER_INT_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEMP_SHUTDOWN_INT_VAL                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   POWER_OK_INT_VAL                         = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_TEST_MODE"
      sgroup "SMBCHG_MISC_TEST_MODE (at 0x16e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TM_IPWR                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TM_CPATH_OS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TM_OTG_EN_HS                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x3 "  [ 3: 1]   TM_BB_LOOPS                              = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_DIS_SYSOV                             = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_TEST_EN"
      sgroup "SMBCHG_MISC_TEST_EN (at 0x16e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TE_IIN_FB                                = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_71_64"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_71_64 (at 0x16e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_71_64                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_63_56"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_63_56 (at 0x16e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_63_56                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_55_48"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_55_48 (at 0x16e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_55_48                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_47_40"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_47_40 (at 0x16e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_47_40                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_39_32"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_39_32 (at 0x16e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_39_32                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_31_24"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_31_24 (at 0x16e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_31_24                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_23_16"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_23_16 (at 0x16ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_23_16                 = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_15_8"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_15_8 (at 0x16eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_15_8                  = "
    tree.end
    tree "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_7_0"
      sgroup "SMBCHG_MISC_TEST_OUTPUT_MUX_IN_7_0 (at 0x16ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_OUTPUT_MUX_IN_7_0                   = "
    tree.end
    tree "SMBCHG_MISC_HVDCP_TST"
      sgroup "SMBCHG_MISC_HVDCP_TST (at 0x16ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HVDCP_TST                                = "
    tree.end
    tree "SMBCHG_MISC_RID_SM_TST"
      sgroup "SMBCHG_MISC_RID_SM_TST (at 0x16ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RID_SM_TST                               = "
    tree.end
    tree "SMBCHG_MISC_SRC_DTC_TST"
      sgroup "SMBCHG_MISC_SRC_DTC_TST (at 0x16ef)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ef0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ef0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SRC_DTC_TST                              = "
    tree.end
    tree "SMBCHG_MISC_TRIM_NUM"
      sgroup "SMBCHG_MISC_TRIM_NUM (at 0x16f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_MISC_WD_CFG"
      sgroup "SMBCHG_MISC_WD_CFG (at 0x16f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AFP_WDOG_ENABLE                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   WDOG_TIMEOUT                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SFT_AFTER_WDOG_IRQ                       = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   WDOG_IRQ_SFT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   WDOG_OPTION                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WDOG_TIMER_EN                            = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_MISC_CFG"
      sgroup "SMBCHG_MISC_MISC_CFG (at 0x16f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SYSOK_LDO                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FETDRV                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   CFG_NTCVOUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PHY_ON                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CHG_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   STANDBY_VCHG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GSM_PA_ON_ADJ_SEL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VCHG_PA_ON_SEL                           = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_CFG_NTC_VOUT"
      sgroup "SMBCHG_MISC_CFG_NTC_VOUT (at 0x16f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CFG_NTC_VOUT                             = "
    tree.end
    tree "SMBCHG_MISC_CHGR_TRIM_OPTIONS_16"
      sgroup "SMBCHG_MISC_CHGR_TRIM_OPTIONS_16 (at 0x16f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_STOP_TBIT                           = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_CHGR_TRIM_OPTIONS_15_8"
      sgroup "SMBCHG_MISC_CHGR_TRIM_OPTIONS_15_8 (at 0x16f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   AICL_INIT                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_ADC                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   USBIN_RERUN_AICL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DCIN_RERUN_AICL                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SYSOK_DCIN_SEL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PRE_BYPASS_GF_TBIT                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STANDBY_OSC_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MAIN_OSC_EN                              = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_CHGR_TRIM_OPTIONS_7_0"
      sgroup "SMBCHG_MISC_CHGR_TRIM_OPTIONS_7_0 (at 0x16f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STANDBY_OSC_TRIM                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TLIM_DIS_TBIT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OV_OPTION_TBIT                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TBIT_IMP_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RLD_DIS_TBIT                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DIS_ARB_FIX_TBIT                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DB_TMR_DIS_TBIT                          = " "0, 1"
    tree.end
    tree "SMBCHG_MISC_TR_IPWR1"
      sgroup "SMBCHG_MISC_TR_IPWR1 (at 0x16f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IPWR1                                 = "
    tree.end
    tree "SMBCHG_MISC_TR_IPWR2"
      sgroup "SMBCHG_MISC_TR_IPWR2 (at 0x16f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_IPWR2                                 = "
    tree.end
    tree "SMBCHG_MISC_TRIM9"
      sgroup "SMBCHG_MISC_TRIM9 (at 0x16f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_VCHG_IOUT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_VCHG_IIN                              = "
    tree.end
    tree "SMBCHG_MISC_TRIM10"
      sgroup "SMBCHG_MISC_TRIM10 (at 0x16fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_TERM                                  = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_BATLOW                                = "
    tree.end
    tree "SMBCHG_MISC_TRIM11"
      sgroup "SMBCHG_MISC_TRIM11 (at 0x16fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TR_RT                                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   TR_1356                                  = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_IOUT_SCALE                            = "
    tree.end
    tree "SMBCHG_MISC_TRIM12"
      sgroup "SMBCHG_MISC_TRIM12 (at 0x16fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IOUTOS                                = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IOUTCS_CHGOS                          = "
    tree.end
    tree "SMBCHG_MISC_TRIM13"
      sgroup "SMBCHG_MISC_TRIM13 (at 0x16fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IOUTCS_OTGOS                          = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IOUTOS_PRECHG                         = "
    tree.end
    tree "SMBCHG_MISC_TRIM14"
      sgroup "SMBCHG_MISC_TRIM14 (at 0x16fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_FLT_SCALE                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_FLT_OFFSET                            = "
    tree.end
    tree "SMBCHG_MISC_CFG_TEMP_SEL"
      sgroup "SMBCHG_MISC_CFG_TEMP_SEL (at 0x16ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_TEMP_SEL                             = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "SMBCHG_OTG"
  tree "SMBCHG_OTG"
    tree "SMBCHG_OTG_PERPH_TYPE"
      sgroup "SMBCHG_OTG_PERPH_TYPE (at 0x1104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_OTG_PERPH_SUBTYPE"
      sgroup "SMBCHG_OTG_PERPH_SUBTYPE (at 0x1105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_OTG_SEC_ACCESS"
      sgroup "SMBCHG_OTG_SEC_ACCESS (at 0x11d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_OTG_PERPH_RESET_CTL2"
      sgroup "SMBCHG_OTG_PERPH_RESET_CTL2 (at 0x11d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_PERPH_RESET_CTL3"
      sgroup "SMBCHG_OTG_PERPH_RESET_CTL3 (at 0x11da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_PERPH_RESET_CTL4"
      sgroup "SMBCHG_OTG_PERPH_RESET_CTL4 (at 0x11db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_SPARE"
      sgroup "SMBCHG_OTG_SPARE (at 0x11df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_OTG_TEST_EN_CFG"
      sgroup "SMBCHG_OTG_TEST_EN_CFG (at 0x11e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TESTMODE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TEST_INPUT_MUX_ENABLE                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_OUTPUT_MUX_ENABLE                   = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_TEST_55_48"
      sgroup "SMBCHG_OTG_TEST_55_48 (at 0x11e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_55_48                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_47_40"
      sgroup "SMBCHG_OTG_TEST_47_40 (at 0x11e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_47_40                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_41_32"
      sgroup "SMBCHG_OTG_TEST_41_32 (at 0x11e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_41_32                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_31_24"
      sgroup "SMBCHG_OTG_TEST_31_24 (at 0x11e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_31_24                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_23_16"
      sgroup "SMBCHG_OTG_TEST_23_16 (at 0x11e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_23_16                               = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_71_64"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_71_64 (at 0x11e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_71_64                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_63_56"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_63_56 (at 0x11e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_63_56                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_55_48"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_55_48 (at 0x11e8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_55_48                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_47_40"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_47_40 (at 0x11e9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_47_40                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_39_32"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_39_32 (at 0x11ea)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_39_32                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_31_24"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_31_24 (at 0x11eb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_31_24                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_23_16"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_23_16 (at 0x11ec)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_23_16                  = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_15_8"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_15_8 (at 0x11ed)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_15_8                   = "
    tree.end
    tree "SMBCHG_OTG_TEST_INPUT_MUX_IN_7_0"
      sgroup "SMBCHG_OTG_TEST_INPUT_MUX_IN_7_0 (at 0x11ee)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011ee0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11ee0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TEST_INPUT_MUX_IN_7_0                    = "
    tree.end
    tree "SMBCHG_OTG_TRIM_NUM"
      sgroup "SMBCHG_OTG_TRIM_NUM (at 0x11f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_OTG_OTG_CFG"
      sgroup "SMBCHG_OTG_OTG_CFG (at 0x11f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   HV_OTG_PROTECTION                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_PIN_POL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OTG_CTRL                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OTG_UVLO_SENSOR_SRC                      = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_OTG_CFG_BATTUV"
      sgroup "SMBCHG_OTG_CFG_BATTUV (at 0x11f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_BATTUV                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_OTG_OTG_ICFG"
      sgroup "SMBCHG_OTG_OTG_ICFG (at 0x11f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OTG_ILIMIT                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_OTG_TR_ISOTG"
      sgroup "SMBCHG_OTG_TR_ISOTG (at 0x11f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TR_ISOTG                                 = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_OTG_TR_OTG_SNS"
      sgroup "SMBCHG_OTG_TR_OTG_SNS (at 0x11f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_OTG_SNS                               = "
    tree.end
    tree "SMBCHG_OTG_TRIM6"
      sgroup "SMBCHG_OTG_TRIM6 (at 0x11f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TR_ENB_ZD                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TR_ENB_SKIP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TR_EN_FPWM_USB1                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_ENLS_SS                               = " "0, 1"
    tree.end
    tree "SMBCHG_OTG_TR_ISTR"
      sgroup "SMBCHG_OTG_TR_ISTR (at 0x11f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   TR_ISTR                                  = "
    tree.end
    tree "SMBCHG_OTG_CFG_TLOOP"
      sgroup "SMBCHG_OTG_CFG_TLOOP (at 0x11f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_TLOOP                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_OTG_CHG_PBS_TRIG_CONTROL"
      sgroup "SMBCHG_OTG_CHG_PBS_TRIG_CONTROL (at 0x11f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   CHG_PBS_TRIG_CONTROL                     = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TR"
      sgroup "SMBCHG_OTG_TR_PWR_TR (at 0x11fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TR                                = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TRB_A"
      sgroup "SMBCHG_OTG_TR_PWR_TRB_A (at 0x11fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRB_A                             = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TRB_B"
      sgroup "SMBCHG_OTG_TR_PWR_TRB_B (at 0x11fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRB_B                             = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TRS"
      sgroup "SMBCHG_OTG_TR_PWR_TRS (at 0x11fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TRS                               = "
    tree.end
    tree "SMBCHG_OTG_TR_PWR_TR_BGTR"
      sgroup "SMBCHG_OTG_TR_PWR_TR_BGTR (at 0x11fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        set &access:&cmd_addr %l 0x8011fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x11fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TR_PWR_TR_BGTR                           = "
    tree.end
  tree.end
tree.end
tree "SMBCHG_USB_CHGPTH"
  tree "SMBCHG_USB_CHGPTH"
    tree "SMBCHG_USB_CHGPTH_PERPH_TYPE"
      sgroup "SMBCHG_USB_CHGPTH_PERPH_TYPE (at 0x1304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_SUBTYPE"
      sgroup "SMBCHG_USB_CHGPTH_PERPH_SUBTYPE (at 0x1305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_ICL_STS_1"
      sgroup "SMBCHG_USB_CHGPTH_ICL_STS_1 (at 0x1307)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_STS                                 = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ICL_STS                                  = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_PWR_PTH_STS"
      sgroup "SMBCHG_USB_CHGPTH_PWR_PTH_STS (at 0x1308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   POWER_PATH                               = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_USB_CHGPTH_ICL_STS_2"
      sgroup "SMBCHG_USB_CHGPTH_ICL_STS_2 (at 0x1309)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AICL_STS                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   ICL_MODE                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   USBIN_SUSPEND_STS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCIN_SUSPEND_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_ACTIVE_PWR_SRC                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DCIN_ACTIVE_PWR_SRC                      = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_APSD_DG_STS"
      sgroup "SMBCHG_USB_CHGPTH_APSD_DG_STS (at 0x130a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCD_TIMEOUT                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DCD_GOOD_DG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OCD_GOOD_DG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RID_ABC_DG                               = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_RID_STS"
      sgroup "SMBCHG_USB_CHGPTH_RID_STS (at 0x130b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RID_STS                                  = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_HVDCP_STS"
      sgroup "SMBCHG_USB_CHGPTH_HVDCP_STS (at 0x130c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IDEV_HVDCP_SEL_A                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HVDCP_SEL_20V                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   HVDCP_SEL_12V                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HVDCP_SEL_9V                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HVDCP_SEL_5V                             = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INPUT_STS"
      sgroup "SMBCHG_USB_CHGPTH_INPUT_STS (at 0x130d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   USBIN_INPUT_STS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DCIN_INPUT_STS                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBID_VALID_ID_11_8"
      sgroup "SMBCHG_USB_CHGPTH_USBID_VALID_ID_11_8 (at 0x130e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   USBID_VALID_ID_11_8                      = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBID_VALID_ID_7_0"
      sgroup "SMBCHG_USB_CHGPTH_USBID_VALID_ID_7_0 (at 0x130f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80130f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x130f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   USBID_VALID_ID_7_0                       = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_RT_STS"
      sgroup "SMBCHG_USB_CHGPTH_INT_RT_STS (at 0x1310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_RT_STS                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_RT_STS                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_RT_STS                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_RT_STS                          = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_SET_TYPE"
      sgroup "SMBCHG_USB_CHGPTH_INT_SET_TYPE (at 0x1311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_TYPE                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_TYPE                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_TYPE                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_TYPE                            = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_POLARITY_HIGH"
      sgroup "SMBCHG_USB_CHGPTH_INT_POLARITY_HIGH (at 0x1312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_HIGH                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_HIGH                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_HIGH                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_HIGH                            = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_POLARITY_LOW"
      sgroup "SMBCHG_USB_CHGPTH_INT_POLARITY_LOW (at 0x1313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_LOW                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LOW                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LOW                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LOW                             = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_LATCHED_CLR"
      sgroup "SMBCHG_USB_CHGPTH_INT_LATCHED_CLR (at 0x1314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_LATCHED_CLR              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LATCHED_CLR            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LATCHED_CLR                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_EN_SET"
      sgroup "SMBCHG_USB_CHGPTH_INT_EN_SET (at 0x1315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_EN_SET                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_EN_SET                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_EN_SET                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_EN_SET                          = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_EN_CLR"
      sgroup "SMBCHG_USB_CHGPTH_INT_EN_CLR (at 0x1316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_EN_CLR                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_EN_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_EN_CLR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_EN_CLR                          = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_LATCHED_STS"
      sgroup "SMBCHG_USB_CHGPTH_INT_LATCHED_STS (at 0x1318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_LATCHED_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_LATCHED_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_LATCHED_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_PENDING_STS"
      sgroup "SMBCHG_USB_CHGPTH_INT_PENDING_STS (at 0x1319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_PENDING_STS              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_PENDING_STS            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_PENDING_STS                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_MID_SEL"
      sgroup "SMBCHG_USB_CHGPTH_INT_MID_SEL (at 0x131a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_PRIORITY"
      sgroup "SMBCHG_USB_CHGPTH_INT_PRIORITY (at 0x131b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80131b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x131b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_CMD_IL"
      sgroup "SMBCHG_USB_CHGPTH_CMD_IL (at 0x1340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BAT_2_SYS_FET_DIS                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USBIN_SUSPEND                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DCIN_SUSPEND                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ICL_OVERRIDE                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51_MODE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_MODE_CHG                           = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_IUSB_MAX"
      sgroup "SMBCHG_USB_CHGPTH_IUSB_MAX (at 0x1344)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IUSB_MAX                                 = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_ENUM_TIMER_STOP"
      sgroup "SMBCHG_USB_CHGPTH_ENUM_TIMER_STOP (at 0x134e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x80134e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x134e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STOP                                     = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_SEC_ACCESS"
      sgroup "SMBCHG_USB_CHGPTH_SEC_ACCESS (at 0x13d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL2"
      sgroup "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL2 (at 0x13d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL3"
      sgroup "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL3 (at 0x13da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL4"
      sgroup "SMBCHG_USB_CHGPTH_PERPH_RESET_CTL4 (at 0x13db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_SPARE"
      sgroup "SMBCHG_USB_CHGPTH_SPARE (at 0x13df)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013df0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13df0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_TEST1"
      sgroup "SMBCHG_USB_CHGPTH_INT_TEST1 (at 0x13e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_INT_TEST_VAL"
      sgroup "SMBCHG_USB_CHGPTH_INT_TEST_VAL (at 0x13e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBID_CHANGE_INTR_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AICL_DONE_INT_VAL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   OTG_OVERCURRENT_INT_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OTG_FAIL_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USBIN_SRC_DET_STS_INT_VAL                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USBIN_OV_INT_VAL                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USBIN_UV_INT_VAL                         = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TM_EN_ATEST_USBIN"
      sgroup "SMBCHG_USB_CHGPTH_TM_EN_ATEST_USBIN (at 0x13e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TM_EN_ATEST_USBIN                        = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM_NUM"
      sgroup "SMBCHG_USB_CHGPTH_TRIM_NUM (at 0x13f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBIN_CHGR_CFG"
      sgroup "SMBCHG_USB_CHGPTH_USBIN_CHGR_CFG (at 0x13f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ADAPTER_ALLOWANCE                        = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_USB_CHGPTH_USBIN_IL_CFG"
      sgroup "SMBCHG_USB_CHGPTH_USBIN_IL_CFG (at 0x13f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CURRENT_LIMIT                            = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_USB_AICL_CFG"
      sgroup "SMBCHG_USB_CHGPTH_USB_AICL_CFG (at 0x13f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OV_OPTION                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DEB_9V_ADAPTER_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DEB_9V_ADAPTER_SEL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DEB_5V_ADAPTER_SEL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   AICL                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DEB_HV_ADAPTER                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEB_LV_ADAPTER                           = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_CFG"
      sgroup "SMBCHG_USB_CHGPTH_CFG (at 0x13f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USBIN_SUSPEND_SRC                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   HVDCP_ADAPTER_SEL                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HVDCP_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USB51_COMMAND_POL                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB51AC_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   USB51AC_PIN_CTRL                         = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_APSD_CFG"
      sgroup "SMBCHG_USB_CHGPTH_APSD_CFG (at 0x13f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INPUT_PRIORITY                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   USB_FAIL_OPTION                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   OCD_ISEL                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SDP_SUSPEND                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   RID_CLK_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   USB_RID                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   AUTO_SRC_DETECT                          = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM6"
      sgroup "SMBCHG_USB_CHGPTH_TRIM6 (at 0x13f6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   TR_SYSON_ILIM                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_SYSON_LDO                             = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_USB100_SNS"
      sgroup "SMBCHG_USB_CHGPTH_TR_USB100_SNS (at 0x13f7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_USB100_SNS                            = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_USB500_SNS"
      sgroup "SMBCHG_USB_CHGPTH_TR_USB500_SNS (at 0x13f8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TR_USB500_SNS                            = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM9"
      sgroup "SMBCHG_USB_CHGPTH_TRIM9 (at 0x13f9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013f90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13f90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TR_IINOS_USBL                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_IINOS_USB                             = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_RID"
      sgroup "SMBCHG_USB_CHGPTH_TR_RID (at 0x13fa)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fa0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fa0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   RID_SEL_CFG                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TR_RID                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TRIM11"
      sgroup "SMBCHG_USB_CHGPTH_TRIM11 (at 0x13fb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   TR_DPDM_PUP                              = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_DPLUS                                 = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_CFG_USB3P0_SEL"
      sgroup "SMBCHG_USB_CHGPTH_CFG_USB3P0_SEL (at 0x13fc)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fc0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fc0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CFG_USB3P0_SEL                           = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_USBIN_DIVIDER"
      sgroup "SMBCHG_USB_CHGPTH_TR_USBIN_DIVIDER (at 0x13fd)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fd0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fd0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TR_USBIN_DIVIDER                         = "
    tree.end
    tree "SMBCHG_USB_CHGPTH_TR_8OR32B"
      sgroup "SMBCHG_USB_CHGPTH_TR_8OR32B (at 0x13fe)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013fe0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13fe0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TR_8OR32B                                = " "0, 1"
    tree.end
    tree "SMBCHG_USB_CHGPTH_SYSON_CFG"
      sgroup "SMBCHG_USB_CHGPTH_SYSON_CFG (at 0x13ff)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        set &access:&cmd_addr %l 0x8013ff0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x1300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x13ff0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SYSON_CFG                                = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_ERROR_DATA"
      sgroup "SPMI_ERROR_DATA (at 0x60b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_DATA                               = "
    tree.end
    tree "SPMI_ERROR_ADDR_LO"
      sgroup "SPMI_ERROR_ADDR_LO (at 0x60c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_LO                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_MD"
      sgroup "SPMI_ERROR_ADDR_MD (at 0x60d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_ADDR_MD                            = "
    tree.end
    tree "SPMI_ERROR_ADDR_HI"
      sgroup "SPMI_ERROR_ADDR_HI (at 0x60e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80060e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x60e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   ERROR_ADDR_HI                            = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_DISABLED),1 (INT_TEST_MODE_ENABLED)"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_ON"
      sgroup "SPMI_OPTIONS_SPMI_ON (at 0x20643)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_ON                                  = " "0 (SPMI_IS_OFF),1 (SPMI_IS_ON)"
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0 (OTP_PROGRAMMED),1 (OTP_NOT_PROGRAMMED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0 (TRIM_NOT_RUN),1 (TRIM_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0 (TRIM_IDLE),1 (TRIM_ACTIVE)"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0 (NO_ERROR),1 (DOUBLE_PROGRAMMING_DETECTED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0 (PROGRAMMING_NOT_RUN),1 (PROGRAMMING_COMPLETED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0 (PROGRAMMING_IDLE),1 (PROGRAMMING_ACTIVE)"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80feda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (RESET_IGNORED),1 (RESET_ARMED)"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0 (DVDD),1 (VPP_EXT)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0 (OTP_PROGRAMMING_DISABLED),1 (OTP_PROGRAMMING_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0 (REGULAR_MODES),1 (RESERVED),2 (MARGIN_1_READ_MODE),3 (MARGIN_2_READ_MODE)"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0 (NO_EFFECT),1 (START_OTP_PROGRAMMING)"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0 (NO_EFFECT),1 (START_COPY)"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0 (NO_EFFECT),1 (READ_OTP_UPPER_BYTES)"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0 (DTEST_DISABLED),1 (DTEST_ENABLED)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0 (TRIM_CLK_DISABLED),1 (TRIM_CLK_ENABLED)"
    tree.end
  tree.end
tree.end
tree "TRI_LED"
  tree "TRI_LED"
    tree "TRI_LED_REVISION1"
      sgroup "TRI_LED_REVISION1 (at 0x1d000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRI_LED_REVISION2"
      sgroup "TRI_LED_REVISION2 (at 0x1d001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRI_LED_REVISION3"
      sgroup "TRI_LED_REVISION3 (at 0x1d002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRI_LED_REVISION4"
      sgroup "TRI_LED_REVISION4 (at 0x1d003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRI_LED_PERPH_TYPE"
      sgroup "TRI_LED_PERPH_TYPE (at 0x1d004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRI_LED_PERPH_SUBTYPE"
      sgroup "TRI_LED_PERPH_SUBTYPE (at 0x1d005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRI_LED_DROPOUT_DET_STATUS"
      sgroup "TRI_LED_DROPOUT_DET_STATUS (at 0x1d008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DROPOUT_DET_R                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DROPOUT_DET_G                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_B                            = " "0 (NO_DROPOUT),1 (DROPOUT_DET)"
    tree.end
    tree "TRI_LED_DROPOUT_DET_STATUS_CLR"
      sgroup "TRI_LED_DROPOUT_DET_STATUS_CLR (at 0x1d009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STATUS_CLR                               = " "0 (NO_CLR),1 (CLR_STS)"
    tree.end
    tree "TRI_LED_INT_RT_STS"
      sgroup "TRI_LED_INT_RT_STS (at 0x1d010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_RT_STS                       = " "0, 1"
    tree.end
    tree "TRI_LED_INT_SET_TYPE"
      sgroup "TRI_LED_INT_SET_TYPE (at 0x1d011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_TYPE                         = " "0 (LEVEL),1 (EDGE)"
    tree.end
    tree "TRI_LED_INT_POLARITY_HIGH"
      sgroup "TRI_LED_INT_POLARITY_HIGH (at 0x1d012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_HIGH                         = " "0 (HIGH_TRIGGER_DISABLED),1 (HIGH_TRIGGER_ENABLED)"
    tree.end
    tree "TRI_LED_INT_POLARITY_LOW"
      sgroup "TRI_LED_INT_POLARITY_LOW (at 0x1d013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LOW                          = " "0 (LOW_TRIGGER_DISABLED),1 (LOW_TRIGGER_ENABLED)"
    tree.end
    tree "TRI_LED_INT_LATCHED_CLR"
      sgroup "TRI_LED_INT_LATCHED_CLR (at 0x1d014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LATCHED_CLR                  = " "0, 1"
    tree.end
    tree "TRI_LED_INT_EN_SET"
      sgroup "TRI_LED_INT_EN_SET (at 0x1d015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_EN_SET                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TRI_LED_INT_EN_CLR"
      sgroup "TRI_LED_INT_EN_CLR (at 0x1d016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_EN_CLR                       = " "0 (INT_DISABLED),1 (INT_ENABLED)"
    tree.end
    tree "TRI_LED_INT_LATCHED_STS"
      sgroup "TRI_LED_INT_LATCHED_STS (at 0x1d018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_LATCHED_STS                  = " "0 (NO_INT_LATCHED),1 (INTERRUPT_LATCHED)"
    tree.end
    tree "TRI_LED_INT_PENDING_STS"
      sgroup "TRI_LED_INT_PENDING_STS (at 0x1d019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_PENDING_STS                  = " "0 (NO_INT_PENDING),1 (INTERRUPT_PENDING)"
    tree.end
    tree "TRI_LED_INT_MID_SEL"
      sgroup "TRI_LED_INT_MID_SEL (at 0x1d01a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0 (MID0),1 (MID1),2 (MID2),3 (MID3)"
    tree.end
    tree "TRI_LED_INT_PRIORITY"
      sgroup "TRI_LED_INT_PRIORITY (at 0x1d01b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "TRI_LED_LED_SRC_SEL"
      sgroup "TRI_LED_LED_SRC_SEL (at 0x1d045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   LED_SRC_SEL                              = " "0 (SRC_GND),1 (SRC_VINRGB_VBOOST),2 (reserved),3 (SRC_4P2V)"
    tree.end
    tree "TRI_LED_EN_CTL"
      sgroup "TRI_LED_EN_CTL (at 0x1d046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RED_EN                                   = " "0 (RED_DIS),1 (RED_EN)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GREEN_EN                                 = " "0 (GREEN_DIS),1 (GREEN_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BLUE_EN                                  = " "0 (BLUE_DIS),1 (BLUE_EN)"
    tree.end
    tree "TRI_LED_EN_CTL_ATC"
      sgroup "TRI_LED_EN_CTL_ATC (at 0x1d047)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RED_ATC_EN                               = " "0 (RED_ATC_DISABLE),1 (RED_ATC_ENABLE)"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GREEN_ATC_EN                             = " "0 (GREEN_ATC_DISABLE),1 (GREEN_ATC_ENABLE)"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   BLUE_ATC_EN                              = " "0 (BLUE_ATC_DISABLE),1 (BLUE_ATC_ENABLE)"
    tree.end
    tree "TRI_LED_DROPOUT_DET"
      sgroup "TRI_LED_DROPOUT_DET (at 0x1d050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DROPOUT_DET                           = " "0 (DET_DIS),1 (DET_EN)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DET_DEBOUNCE                             = " "0 (NO_DEBOUNCE),1 (DEBOUNCE_10US),2 (reserved),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   DET_SEL                                  = " "0 (VIN_RGB),1 (RED),2 (GREEN),3 (BLUE)"
    tree.end
    tree "TRI_LED_SEC_ACCESS"
      sgroup "TRI_LED_SEC_ACCESS (at 0x1d0d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL1"
      sgroup "TRI_LED_PERPH_RESET_CTL1 (at 0x1d0d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (PRESET_DISABLE),1 (PRESET_ENABLE)"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL2"
      sgroup "TRI_LED_PERPH_RESET_CTL2 (at 0x1d0d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL3"
      sgroup "TRI_LED_PERPH_RESET_CTL3 (at 0x1d0da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TRI_LED_PERPH_RESET_CTL4"
      sgroup "TRI_LED_PERPH_RESET_CTL4 (at 0x1d0db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (NORMAL_OPERATION),1 (SOFT_RESET_ASSERTED)"
    tree.end
    tree "TRI_LED_INT_TEST1"
      sgroup "TRI_LED_INT_TEST1 (at 0x1d0e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (NO_REPLACE),1 (INV_TEST_VAL)"
    tree.end
    tree "TRI_LED_INT_TEST_VAL"
      sgroup "TRI_LED_INT_TEST_VAL (at 0x1d0e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DROPOUT_DET_TEST_VAL                     = " "0 (TEST_VAL_0),1 (TEST_VAL_1)"
    tree.end
    tree "TRI_LED_TEST1"
      sgroup "TRI_LED_TEST1 (at 0x1d0e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   CLOSE_LOOP_TEST_EN                       = " "0 (CL_TEST_DIS),1 (BLUE),2 (GREEN),3 (RED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   OPEN_LOOP_CAL_EN                         = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_MODE_EN                            = " "0 (ATEST_DIS),1 (ATEST_EN)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_SEL                                  = " "0 (LPG_PWM),1 (DTEST1)"
    tree.end
    tree "TRI_LED_TRIM_NUM"
      sgroup "TRI_LED_TRIM_NUM (at 0x1d0f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TRI_LED_R_8MA_CURRENT_TRIM"
      sgroup "TRI_LED_R_8MA_CURRENT_TRIM (at 0x1d0f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   R_8MA_CURRENT_TRIM                       = "
    tree.end
    tree "TRI_LED_G_8MA_CURRENT_TRIM"
      sgroup "TRI_LED_G_8MA_CURRENT_TRIM (at 0x1d0f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   G_8MA_CURRENT_TRIM                       = "
    tree.end
    tree "TRI_LED_B_8MA_CURRENT_TRIM"
      sgroup "TRI_LED_B_8MA_CURRENT_TRIM (at 0x1d0f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        set &access:&cmd_addr %l 0x80d0f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0xd000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xd0f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   B_8MA_CURRENT_TRIM                       = "
    tree.end
  tree.end
tree.end
tree "VADC_USR"
  tree "VADC_USR"
    tree "VADC_USR_REVISION1"
      sgroup "VADC_USR_REVISION1 (at 0x3100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "VADC_USR_REVISION2"
      sgroup "VADC_USR_REVISION2 (at 0x3101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "VADC_USR_REVISION3"
      sgroup "VADC_USR_REVISION3 (at 0x3102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "VADC_USR_REVISION4"
      sgroup "VADC_USR_REVISION4 (at 0x3103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "VADC_USR_PERPH_TYPE"
      sgroup "VADC_USR_PERPH_TYPE (at 0x3104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "VADC_USR_PERPH_SUBTYPE"
      sgroup "VADC_USR_PERPH_SUBTYPE (at 0x3105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "VADC_USR_STATUS1"
      sgroup "VADC_USR_STATUS1 (at 0x3108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MEAS_INTERVAL_EN_STS                     = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   REQ_STS                                  = " "0 (REQ_NOT_IN_PROGRESS),1 (REQ_IN_PROGRESS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC                                      = " "0 (CONV_NOT_COMPLETE),1 (CONV_COMPLETE)"
    tree.end
    tree "VADC_USR_STATUS2"
      sgroup "VADC_USR_STATUS2 (at 0x3109)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   CONV_SEQ_STATE                           = "
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_FLAG                      = " "0 (FIFO_EMPTY_WHEN_REQ_MADE),1 (FIFO_NOT_EMPTY_WHEN_REQ_MADE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CONV_SEQ_TIMEOUT_STS                     = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
    tree.end
    tree "VADC_USR_INT_RT_STS"
      sgroup "VADC_USR_INT_RT_STS (at 0x3110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_RT_STS                       = " "0 (LOW_THR_INT_FALSE),1 (LOW_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_RT_STS                      = " "0 (HIGH_THR_INT_FALSE),1 (HIGH_THR_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_RT_STS              = " "0 (CONV_SEQ_TIMEOUT_FALSE),1 (CONV_SEQ_TIMEOUT_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_RT_STS                = " "0 (FIFO_NOT_EMPTY_INT_FALSE),1 (FIFO_EMPTY_INT_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_RT_STS                           = " "0 (CONV_COMPLETE_INT_FALSE),1 (CONV_COMPLETE_INT_TRUE)"
    tree.end
    tree "VADC_USR_INT_SET_TYPE"
      sgroup "VADC_USR_INT_SET_TYPE (at 0x3111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_SET_TYPE                     = " "0 (LOW_THR_INT_LEVEL),1 (LOW_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_SET_TYPE                    = " "0 (HIGH_THR_INT_LEVEL),1 (HIGH_THR_INT_EDGE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_SET_TYPE            = " "0 (CONV_SEQ_TIMEOUT_LEVEL),1 (CONV_SEQ_TIMEOUT_EDGE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_SET_TYPE              = " "0 (FIFO_NOT_EMPTY_LEVEL),1 (FIFO_NOT_EMPTY_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_SET_INT_TYPE                         = " "0 (EOC_LEVEL),1 (EOC_EDGE)"
    tree.end
    tree "VADC_USR_INT_POLARITY_HIGH"
      sgroup "VADC_USR_INT_POLARITY_HIGH (at 0x3112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_HIGH_DISABLED),1 (LOW_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_HIGH_DISABLED),1 (HIGH_THR_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_HIGH                = " "0 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_HIGH                  = " "0 (FIFO_NOT_EMPTY_INT_POL_HIGH_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_HIGH_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_HIGH                             = " "0 (EOC_INT_POL_HIGH_DISABLED),1 (EOC_INT_POL_HIGH_ENABLED)"
    tree.end
    tree "VADC_USR_INT_POLARITY_LOW"
      sgroup "VADC_USR_INT_POLARITY_LOW (at 0x3113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_HIGH                         = " "0 (LOW_THR_INT_POL_LOW_DISABLED),1 (LOW_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_HIGH                        = " "0 (HIGH_THR_INT_POL_LOW_DISABLED),1 (HIGH_THR_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LOW                 = " "0 (CONV_SEQ_TIMEOUT_INT_POL_LOW_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LOW                   = " "0 (FIFO_NOT_EMPTY_INT_POL_LOW_DISABLED),1 (FIFO_NOT_EMPTY_INT_POL_LOW_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LOW                              = " "0 (EOC_INT_POL_LOW_DISABLED),1 (EOC_INT_POL_LOW_ENABLED)"
    tree.end
    tree "VADC_USR_INT_LATCHED_CLR"
      sgroup "VADC_USR_INT_LATCHED_CLR (at 0x3114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_CLR                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_CLR                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_CLR         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_CLR           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_CLR                      = " "0, 1"
    tree.end
    tree "VADC_USR_INT_EN_SET"
      sgroup "VADC_USR_INT_EN_SET (at 0x3115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_SET                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_SET                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_SET              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_SET                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_SET                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_USR_INT_EN_CLR"
      sgroup "VADC_USR_INT_EN_CLR (at 0x3116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_EN_CLR                       = " "0 (LOW_THR_INT_DISABLED),1 (LOW_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_EN_CLR                      = " "0 (HIGH_THR_INT_DISABLED),1 (HIGH_THR_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_EN_CLR              = " "0 (CONV_SEQ_TIMEOUT_INT_DISABLED),1 (CONV_SEQ_TIMEOUT_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_EN_CLR                = " "0 (FIFO_NOT_EMPTY_INT_DISABLED),1 (FIFO_NOT_EMPTY_INT_ENBLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_EN_CLR                           = " "0 (EOC_INT_DISABLED),1 (EOC_INT_ENBLED)"
    tree.end
    tree "VADC_USR_INT_LATCHED_STS"
      sgroup "VADC_USR_INT_LATCHED_STS (at 0x3118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_LATCHED_STS                  = " "0 (LOW_THR_INT_LATCHED_FALSE),1 (LOW_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_LATCHED_STS                 = " "0 (HIGH_THR_INT_LATCHED_FALSE),1 (HIGH_THR_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_LATCHED_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_LATCHED_FALSE),1 (CONV_SEQ_TIMEOUT_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_LATCHED_STS           = " "0 (FIFO_NOT_EMPTY_INT_LATCHED_FALSE),1 (FIFO_NOT_EMPTY_INT_LATCHED_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_LATCHED_STS                      = " "0 (EOC_INT_LATCHED_FALSE),1 (EOC_INT_LATCHED_TRUE)"
    tree.end
    tree "VADC_USR_INT_PENDING_STS"
      sgroup "VADC_USR_INT_PENDING_STS (at 0x3119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_PENDING_STS                  = " "0 (LOW_THR_INT_PENDING_FALSE),1 (LOW_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_PENDING_STS                 = " "0 (HIGH_THR_INT_PENDING_FALSE),1 (HIGH_THR_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_PENDING_STS         = " "0 (CONV_SEQ_TIMEOUT_INT_PENDING_FALSE),1 (CONV_SEQ_TIMEOUT_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_PENDING_STS           = " "0 (FIFO_NOT_EMPTY_INT_PENDING_FALSE),1 (FIFO_NOT_EMPTY_INT_PENDING_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_PENDING_STS                      = " "0 (EOC_INT_PENDING_FALSE),1 (EOC_INT_PENDING_TRUE)"
    tree.end
    tree "VADC_USR_INT_MID_SEL"
      sgroup "VADC_USR_INT_MID_SEL (at 0x311a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "VADC_USR_INT_PRIORITY"
      sgroup "VADC_USR_INT_PRIORITY (at 0x311b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80311b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x311b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0 (SR),1 (A)"
    tree.end
    tree "VADC_USR_MODE_CTL"
      sgroup "VADC_USR_MODE_CTL (at 0x3140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   OP_MODE                                  = " "0 (NORM_MODE),1 (CONV_SEQ_MODE),2 (MEAS_INT_MODE),3 (reserved)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREF_XO_THM_FORCE                        = " "0 (VREF_XO_THM_FORCE_FALSE),1 (VREF_XO_THM_FORCE_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   AMUX_TRIM_EN                             = " "0 (AMUX_TRIM_DISABLED),1 (AMUX_TRIM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ADC_TRIM_EN                              = " "0 (ADC_TRIM_DISABLED),1 (ADC_TRIM_ENABLED)"
    tree.end
    tree "VADC_USR_EN_CTL1"
      sgroup "VADC_USR_EN_CTL1 (at 0x3146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ADC_EN                                   = " "0 (ADC_DISABLED),1 (ADC_ENABLED)"
    tree.end
    tree "VADC_USR_ADC_CH_SEL_CTL"
      sgroup "VADC_USR_ADC_CH_SEL_CTL (at 0x3148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ADC_CH_SEL                               = "
    tree.end
    tree "VADC_USR_ADC_DIG_PARAM"
      sgroup "VADC_USR_ADC_DIG_PARAM (at 0x3150)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   DEC_RATIO_SEL                            = " "0 (DECI_512),1 (DECI_1K),2 (DECI_2K),3 (DECI_4K)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CLK_SEL                                  = " "0 (CLK_SEL_2P4MHZ),1 (CLK_SEL_4P8MHZ),2 (CLK_SEL_9P6MHZ),3 (CLK_SEL_19P2MHZ)"
    tree.end
    tree "VADC_USR_HW_SETTLE_DELAY"
      sgroup "VADC_USR_HW_SETTLE_DELAY (at 0x3151)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   HW_SETTLE_DELAY                          = "
    tree.end
    tree "VADC_USR_CONV_REQ"
      sgroup "VADC_USR_CONV_REQ (at 0x3152)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REQ                                      = " "0 (CONV_REQ_FALSE),1 (CONV_REQ_TRUE)"
    tree.end
    tree "VADC_USR_CONV_SEQ_CTL"
      sgroup "VADC_USR_CONV_SEQ_CTL (at 0x3154)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   CONV_SEQ_HOLDOFF                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CONV_SEQ_TIMEOUT                         = "
    tree.end
    tree "VADC_USR_CONV_SEQ_TRIG_CTL"
      sgroup "VADC_USR_CONV_SEQ_TRIG_CTL (at 0x3155)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CONV_SEQ_TRIG_COND                       = " "0 (FALLING_EDGE),1 (RISING_EDGE)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CONV_SEQ_TRIG_SEL                        = " "0 (ADC_TRIG0),1 (ADC_TRIG1),2 (ADC_TRIG2),3 (ADC_TRIG3)"
    tree.end
    tree "VADC_USR_MEAS_INTERVAL_CTL"
      sgroup "VADC_USR_MEAS_INTERVAL_CTL (at 0x3157)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MEAS_INTERVAL_TIME                       = "
    tree.end
    tree "VADC_USR_MEAS_INTERVAL_OP_CTL"
      sgroup "VADC_USR_MEAS_INTERVAL_OP_CTL (at 0x3159)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MEAS_INTERVAL_OP                         = " "0 (INTERVAL_MODE_DISABLED),1 (INTERVAL_MODE_ENABLED)"
    tree.end
    tree "VADC_USR_FAST_AVG_CTL"
      sgroup "VADC_USR_FAST_AVG_CTL (at 0x315a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FAST_AVG_SAMPLES                         = "
    tree.end
    tree "VADC_USR_FAST_AVG_EN"
      sgroup "VADC_USR_FAST_AVG_EN (at 0x315b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FAST_AVG_EN                              = " "0 (FAST_AVG_DISABLED),1 (FAST_AVG_ENABLED)"
    tree.end
    tree "VADC_USR_LOW_THR0"
      sgroup "VADC_USR_LOW_THR0 (at 0x315c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_7_0                              = "
    tree.end
    tree "VADC_USR_LOW_THR1"
      sgroup "VADC_USR_LOW_THR1 (at 0x315d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LOW_THR_15_8                             = "
    tree.end
    tree "VADC_USR_HIGH_THR0"
      sgroup "VADC_USR_HIGH_THR0 (at 0x315e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_7_0                             = "
    tree.end
    tree "VADC_USR_HIGH_THR1"
      sgroup "VADC_USR_HIGH_THR1 (at 0x315f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x80315f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x315f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   HIGH_THR_15_8                            = "
    tree.end
    tree "VADC_USR_DATA0"
      sgroup "VADC_USR_DATA0 (at 0x3160)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_7_0                                 = "
    tree.end
    tree "VADC_USR_DATA1"
      sgroup "VADC_USR_DATA1 (at 0x3161)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DATA_15_8                                = "
    tree.end
    tree "VADC_USR_SEC_ACCESS"
      sgroup "VADC_USR_SEC_ACCESS (at 0x31d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "VADC_USR_PERPH_RESET_CTL1"
      sgroup "VADC_USR_PERPH_RESET_CTL1 (at 0x31d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0 (MODULE_DIS_AFTER_WARM_SOFT_RESET),1 (MODULE_EN_AFTER_WARM_SOFT_RESET)"
    tree.end
    tree "VADC_USR_PERPH_RESET_CTL2"
      sgroup "VADC_USR_PERPH_RESET_CTL2 (at 0x31d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0 (FOLLOW_GLOBAL_SOFT_RESET_FALSE),1 (FOLLOW_GLOBAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_USR_PERPH_RESET_CTL3"
      sgroup "VADC_USR_PERPH_RESET_CTL3 (at 0x31da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0 (FOLLOW_OTST2_RB_FALSE),1 (FOLLOW_OTST2_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0 (FOLLOW_WARM_RB_FALSE),1 (FOLLOW_WARM_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0 (FOLLOW_SHUTDOWN1_RB_FALSE),1 (FOLLOW_SHUTDOWN1_RB_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0 (FOLLOW_SHUTDOWN2_RB_FALSE),1 (FOLLOW_SHUTDOWN2_RB_TRUE)"
    tree.end
    tree "VADC_USR_PERPH_RESET_CTL4"
      sgroup "VADC_USR_PERPH_RESET_CTL4 (at 0x31db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0 (LOCAL_SOFT_RESET_FALSE),1 (LOCAL_SOFT_RESET_TRUE)"
    tree.end
    tree "VADC_USR_INT_TEST1"
      sgroup "VADC_USR_INT_TEST1 (at 0x31e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0 (INT_TEST_MODE_FALSE),1 (INT_TEST_MODE_TRUE)"
    tree.end
    tree "VADC_USR_INT_TEST_VAL"
      sgroup "VADC_USR_INT_TEST_VAL (at 0x31e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   LOW_THR_INT_TEST_VAL                     = " "0 (LOW_THR_INT_TEST_FALSE),1 (LOW_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   HIGH_THR_INT_TEST_VAL                    = " "0 (HIGH_THR_INT_TEST_FALSE),1 (HIGH_THR_INT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CONV_SEQ_TIMEOUT_INT_TEST_VAL            = " "0 (CONV_SEQ_TIMEOUT_TEST_FALSE),1 (CONV_SEQ_TIMEOUT_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FIFO_NOT_EMPTY_INT_TEST_VAL              = " "0 (FIFO_NOT_EMPTY_TEST_FALSE),1 (FIFO_NOT_EMPTY_TEST_TRUE)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   EOC_INT_TEST_VAL                         = " "0 (EOC_TEST_FALSE),1 (EOC_TEST_TRUE)"
    tree.end
    tree "VADC_USR_TEST1_ADC_ANA_PARAM"
      sgroup "VADC_USR_TEST1_ADC_ANA_PARAM (at 0x31e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   HS_MODE_EN                               = " "0 (DISABLE_HS_MODE_N),1 (ENABLE_HS_MODE_N)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   IOTA1_CTL                                = " "0 (OTA1_1UA_BIAS),1 (OTA1_2UA_BIAS),2 (OTA1_3UA_BIAS),3 (OTA1_4UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   IOTA2_CTL                                = " "0 (OTA2_1UA_BIAS),1 (OTA2_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IBUF_CTL                                 = " "0 (REF_1UA_BIAS),1 (REF_2UA_BIAS)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XOADC_EN                                 = " "0 (XOADC_MOD_DISABLED),1 (XOADC_MOD_ENABLED)"
    tree.end
    tree "VADC_USR_TEST2_ADC_DIG_PARAM"
      sgroup "VADC_USR_TEST2_ADC_DIG_PARAM (at 0x31e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DEM_EN                                   = " "0 (DEM_DISABLED),1 (DEM_ENABLED)"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_GATE_EN                              = " "0 (CLK_GATE_DISABLED),1 (CLK_GATE_ENABLED)"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   SEL_SHIFT                                = " "0 (DECI_SEL),1 (FILTOUT_15_0),2 (FILTOUT_25_16),3 (DECI_SEL1)"
    tree.end
    tree "VADC_USR_TEST3_ADC_RSV"
      sgroup "VADC_USR_TEST3_ADC_RSV (at 0x31e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SINC_FILT_SEL                            = " "0 (SINC2_OUTPUT),1 (SINC1_OUTPUT)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESET_SINC_FILT                          = " "0 (RESET_DIG_FILT_FALSE),1 (RESET_DIG_FILT_TRUE)"
    tree.end
    tree "VADC_USR_TEST4_ADC_ATEST"
      sgroup "VADC_USR_TEST4_ADC_ATEST (at 0x31e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REF_EN                                   = " "0 (DISABLE_XOADC_REF_VOLT),1 (ENABLE_XOADC_REF_VOLTAGE)"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   VICM_SEL                                 = " "0 (VICM_0P65),1 (VICM_0P70),2 (VICM_0P75),3 (VICM_OP80)"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VOCM_SEL                                 = " "0 (VOCM_0P60),1 (VOCM_0P65),2 (VOCM_0P70),3 (VOCM_0P75)"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST_SEL                                = " "0 (ATEST3_DISABLED),1 (VTH_N),2 (VTH_P),3 (VICM),4 (VOCM),5 (VREFN),6 (VREFMID),7 (VREFP)"
    tree.end
    tree "VADC_USR_TEST5_AMUX_ATEST"
      sgroup "VADC_USR_TEST5_AMUX_ATEST (at 0x31e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST2_SEL                               = " "0 (NORM_OP),1 (AMUX_OUT_TO_ATEST2)"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST1_SEL                               = " "0 (NORM_OP),1 (ATEST1_TO_INPUT_OF_OUTPUT_BUF)"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_EN                                   = " "0 (OL_CAL_DIS),1 (OL_CAL_EN)"
    tree.end
    tree "VADC_USR_TEST6_DTEST"
      sgroup "VADC_USR_TEST6_DTEST (at 0x31e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SEL_FSM                                  = " "0 (REQUEST_FSM),1 (VADC_CONVERSION_FSM),2 (SAMPLE_COUNT_LSB),3 (SAMPLE_COUNT_MSB)"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "VADC_USR_TRIM_NUM"
      sgroup "VADC_USR_TRIM_NUM (at 0x31f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "VADC_USR_TRIM1_ADC"
      sgroup "VADC_USR_TRIM1_ADC (at 0x31f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DAC_REF                                  = "
    tree.end
    tree "VADC_USR_TRIM1_AMUX"
      sgroup "VADC_USR_TRIM1_AMUX (at 0x31f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   PRESCALE_167_RATIO                       = "
    tree.end
    tree "VADC_USR_TRIM2_AMUX"
      sgroup "VADC_USR_TRIM2_AMUX (at 0x31f3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   PRESCALE_333_RATIO                       = "
    tree.end
    tree "VADC_USR_TRIM4_AMUX"
      sgroup "VADC_USR_TRIM4_AMUX (at 0x31f4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_LOW_OFFSET                           = "
    tree.end
    tree "VADC_USR_TRIM5_AMUX"
      sgroup "VADC_USR_TRIM5_AMUX (at 0x31f5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        set &access:&cmd_addr %l 0x8031f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x3100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x31f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   BUF_HIGH_OFFSET                          = "
    tree.end
  tree.end
tree.end

