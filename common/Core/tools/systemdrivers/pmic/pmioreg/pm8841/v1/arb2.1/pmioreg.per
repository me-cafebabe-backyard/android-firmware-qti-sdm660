entry &access &sid &cmd_addr &read_addr &write_addr &chan_addr
tree "BCLK_GEN_MAIN"
  tree "BCLK_GEN_MAIN"
    tree "BCLK_GEN_MAIN_REVISION1"
      sgroup "BCLK_GEN_MAIN_REVISION1 (at 0x11000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION2"
      sgroup "BCLK_GEN_MAIN_REVISION2 (at 0x11001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION3"
      sgroup "BCLK_GEN_MAIN_REVISION3 (at 0x11002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_REVISION4"
      sgroup "BCLK_GEN_MAIN_REVISION4 (at 0x11003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_TYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_TYPE (at 0x11004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_SUBTYPE"
      sgroup "BCLK_GEN_MAIN_PERPH_SUBTYPE (at 0x11005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BCLK_GEN_MAIN_STATUS"
      sgroup "BCLK_GEN_MAIN_STATUS (at 0x11008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DLL_LOCK_FLG                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_RT_STS"
      sgroup "BCLK_GEN_MAIN_INT_RT_STS (at 0x11010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_RT_STS                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_SET_TYPE"
      sgroup "BCLK_GEN_MAIN_INT_SET_TYPE (at 0x11011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TYPE                            = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_HIGH"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_HIGH (at 0x11012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_HIGH                            = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_POLARITY_LOW"
      sgroup "BCLK_GEN_MAIN_INT_POLARITY_LOW (at 0x11013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LOW                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_CLR"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_CLR (at 0x11014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_SET"
      sgroup "BCLK_GEN_MAIN_INT_EN_SET (at 0x11015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_SET                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_EN_CLR"
      sgroup "BCLK_GEN_MAIN_INT_EN_CLR (at 0x11016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_EN_CLR                          = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_LATCHED_STS"
      sgroup "BCLK_GEN_MAIN_INT_LATCHED_STS (at 0x11018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PENDING_STS"
      sgroup "BCLK_GEN_MAIN_INT_PENDING_STS (at 0x11019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_PENDING_STS                     = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_MID_SEL"
      sgroup "BCLK_GEN_MAIN_INT_MID_SEL (at 0x1101a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "BCLK_GEN_MAIN_INT_PRIORITY"
      sgroup "BCLK_GEN_MAIN_INT_PRIORITY (at 0x1101b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x80101b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x101b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_BCLK_GEN_ENABLE"
      sgroup "BCLK_GEN_MAIN_BCLK_GEN_ENABLE (at 0x11046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_BCLK_GEN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_REQ                           = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_DLL_CFG"
      sgroup "BCLK_GEN_MAIN_DLL_CFG (at 0x11050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   DLL_LOCK_CFG                             = " "0, 1, 2, 3"
    tree.end
    tree "BCLK_GEN_MAIN_SEC_ACCESS"
      sgroup "BCLK_GEN_MAIN_SEC_ACCESS (at 0x110d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL2"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL2 (at 0x110d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL3"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL3 (at 0x110da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_PERPH_RESET_CTL4"
      sgroup "BCLK_GEN_MAIN_PERPH_RESET_CTL4 (at 0x110db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST1"
      sgroup "BCLK_GEN_MAIN_INT_TEST1 (at 0x110e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_INT_TEST_VAL"
      sgroup "BCLK_GEN_MAIN_INT_TEST_VAL (at 0x110e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DLL_LOCK_TEST_VAL                        = " "0, 1"
    tree.end
    tree "BCLK_GEN_MAIN_TEST1"
      sgroup "BCLK_GEN_MAIN_TEST1 (at 0x110e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST1_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST2_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST2"
      sgroup "BCLK_GEN_MAIN_TEST2 (at 0x110e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST3_SEL                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST4_SEL                               = "
    tree.end
    tree "BCLK_GEN_MAIN_TEST3"
      sgroup "BCLK_GEN_MAIN_TEST3 (at 0x110e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "BCLK_GEN_MAIN_TEST4"
      sgroup "BCLK_GEN_MAIN_TEST4 (at 0x110e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        set &access:&cmd_addr %l 0x8010e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x10e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_CLK_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   TEST_CLK_SEL                             = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "BUS"
  tree "BUS"
    tree "BUS_REVISION1"
      sgroup "BUS_REVISION1 (at 0x400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "BUS_REVISION2"
      sgroup "BUS_REVISION2 (at 0x401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "BUS_PERPH_TYPE"
      sgroup "BUS_PERPH_TYPE (at 0x404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "BUS_PERPH_SUBTYPE"
      sgroup "BUS_PERPH_SUBTYPE (at 0x405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "BUS_STATUS1"
      sgroup "BUS_STATUS1 (at 0x408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INTBUS_ARB_GNT                           = "
    tree.end
    tree "BUS_TIMEOUT"
      sgroup "BUS_TIMEOUT (at 0x444)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   TIMEOUT_MANT                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   TIMEOUT_EXP                              = "
    tree.end
    tree "BUS_SEC_ACCESS"
      sgroup "BUS_SEC_ACCESS (at 0x4d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "BUS_PERPH_RESET_CTL2"
      sgroup "BUS_PERPH_RESET_CTL2 (at 0x4d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "BUS_PERPH_RESET_CTL3"
      sgroup "BUS_PERPH_RESET_CTL3 (at 0x4da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "BUS_PERPH_RESET_CTL4"
      sgroup "BUS_PERPH_RESET_CTL4 (at 0x4db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "BUS_TEST1"
      sgroup "BUS_TEST1 (at 0x4e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        set &access:&cmd_addr %l 0x8004e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x4e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "CLK_DIST"
  tree "CLK_DIST"
    tree "CLK_DIST_REVISION1"
      sgroup "CLK_DIST_REVISION1 (at 0x5900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION2"
      sgroup "CLK_DIST_REVISION2 (at 0x5901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "CLK_DIST_REVISION3"
      sgroup "CLK_DIST_REVISION3 (at 0x5902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "CLK_DIST_REVISION4"
      sgroup "CLK_DIST_REVISION4 (at 0x5903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "CLK_DIST_PERPH_TYPE"
      sgroup "CLK_DIST_PERPH_TYPE (at 0x5904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "CLK_DIST_PERPH_SUBTYPE"
      sgroup "CLK_DIST_PERPH_SUBTYPE (at 0x5905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "CLK_DIST_STATUS1"
      sgroup "CLK_DIST_STATUS1 (at 0x5908)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RC19M_OK                                 = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_RT_STS"
      sgroup "CLK_DIST_INT_RT_STS (at 0x5910)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_RT_STS                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_SET_TYPE"
      sgroup "CLK_DIST_INT_SET_TYPE (at 0x5911)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TYPE                     = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_POLARITY_HIGH"
      sgroup "CLK_DIST_INT_POLARITY_HIGH (at 0x5912)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_HIGH                     = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_POLARITY_LOW"
      sgroup "CLK_DIST_INT_POLARITY_LOW (at 0x5913)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LOW                      = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_LATCHED_CLR"
      sgroup "CLK_DIST_INT_LATCHED_CLR (at 0x5914)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_CLR              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_SET"
      sgroup "CLK_DIST_INT_EN_SET (at 0x5915)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_SET                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_EN_CLR"
      sgroup "CLK_DIST_INT_EN_CLR (at 0x5916)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_EN_CLR                   = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_LATCHED_STS"
      sgroup "CLK_DIST_INT_LATCHED_STS (at 0x5918)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_LATCHED_STS              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_PENDING_STS"
      sgroup "CLK_DIST_INT_PENDING_STS (at 0x5919)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_PENDING_STS              = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_MID_SEL"
      sgroup "CLK_DIST_INT_MID_SEL (at 0x591a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_INT_PRIORITY"
      sgroup "CLK_DIST_INT_PRIORITY (at 0x591b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x80591b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x591b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL1"
      sgroup "CLK_DIST_CLK_CTL1 (at 0x5940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   SMPS_CLK_SEL                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   GPCLK_19M2_SEL                           = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XORC19M2_CLK_SEL                         = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_CLK_CTL2"
      sgroup "CLK_DIST_CLK_CTL2 (at 0x5941)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_SC                               = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL3"
      sgroup "CLK_DIST_CLK_CTL3 (at 0x5942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEL_ALT_RTC                              = " "0, 1"
    tree.end
    tree "CLK_DIST_CLK_CTL4"
      sgroup "CLK_DIST_CLK_CTL4 (at 0x5943)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_32K_RC                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO32K_CLK_SEL                            = " "0, 1"
    tree.end
    tree "CLK_DIST_HALT_CTL"
      sgroup "CLK_DIST_HALT_CTL (at 0x5945)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   XO19M2_HALT_DET_EN                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_XO19M2_OSC_HALT                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HOLD_XO19M2_OSC_HALT                     = " "0, 1"
    tree.end
    tree "CLK_DIST_RC_CTL"
      sgroup "CLK_DIST_RC_CTL (at 0x5946)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_RC19M2_OSC_ON                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RC19M2_OSC_HW_CTL                        = " "0, 1"
    tree.end
    tree "CLK_DIST_PD_CTL"
      sgroup "CLK_DIST_PD_CTL (at 0x5948)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "CLK_DIST_SEC_ACCESS"
      sgroup "CLK_DIST_SEC_ACCESS (at 0x59d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL2"
      sgroup "CLK_DIST_PERPH_RESET_CTL2 (at 0x59d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL3"
      sgroup "CLK_DIST_PERPH_RESET_CTL3 (at 0x59da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "CLK_DIST_PERPH_RESET_CTL4"
      sgroup "CLK_DIST_PERPH_RESET_CTL4 (at 0x59db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST1"
      sgroup "CLK_DIST_INT_TEST1 (at 0x59e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "CLK_DIST_INT_TEST_VAL"
      sgroup "CLK_DIST_INT_TEST_VAL (at 0x59e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   XO19M2_HALT_DET_TEST_VAL                 = " "0, 1"
    tree.end
    tree "CLK_DIST_TEST1"
      sgroup "CLK_DIST_TEST1 (at 0x59e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "CLK_DIST_TEST2"
      sgroup "CLK_DIST_TEST2 (at 0x59e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   TESTCLK_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   CLK_32KHZ_SEL                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CLK_1KHZ_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SMPS_CLK_SEL                             = " "0, 1"
    tree.end
    tree "CLK_DIST_TRIM_NUM"
      sgroup "CLK_DIST_TRIM_NUM (at 0x59f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "CLK_DIST_RC19M2_TRIM"
      sgroup "CLK_DIST_RC19M2_TRIM (at 0x59f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   BCK_RCI                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BCK_RCC                                  = " "0, 1, 2, 3"
    tree.end
    tree "CLK_DIST_RCLF_TRIM"
      sgroup "CLK_DIST_RCLF_TRIM (at 0x59f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        set &access:&cmd_addr %l 0x8059f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x5900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x59f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   RCLF_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "INT"
  tree "INT"
    tree "INT_REVISION1"
      sgroup "INT_REVISION1 (at 0x500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "INT_REVISION2"
      sgroup "INT_REVISION2 (at 0x501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "INT_PERPH_TYPE"
      sgroup "INT_PERPH_TYPE (at 0x504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "INT_PERPH_SUBTYPE"
      sgroup "INT_PERPH_SUBTYPE (at 0x505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "INT_STATUS1"
      sgroup "INT_STATUS1 (at 0x508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   CLK_REQ                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEND_REQ                                 = " "0, 1"
    tree.end
    tree "INT_STATUS2"
      sgroup "INT_STATUS2 (at 0x509)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LAST_WINNER                              = "
    tree.end
    tree "INT_INT_RESEND_ALL"
      sgroup "INT_INT_RESEND_ALL (at 0x540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_RESEND_ALL                           = " "0, 1"
    tree.end
    tree "INT_EN_CTL1"
      sgroup "INT_EN_CTL1 (at 0x546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INTR_EN                                  = " "0, 1"
    tree.end
    tree "INT_SEC_ACCESS"
      sgroup "INT_SEC_ACCESS (at 0x5d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "INT_PERPH_RESET_CTL1"
      sgroup "INT_PERPH_RESET_CTL1 (at 0x5d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL2"
      sgroup "INT_PERPH_RESET_CTL2 (at 0x5d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL3"
      sgroup "INT_PERPH_RESET_CTL3 (at 0x5da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "INT_PERPH_RESET_CTL4"
      sgroup "INT_PERPH_RESET_CTL4 (at 0x5db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "INT_TEST1"
      sgroup "INT_TEST1 (at 0x5e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        set &access:&cmd_addr %l 0x8005e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x5e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST                                    = "
    tree.end
  tree.end
tree.end
tree "MBG1"
  tree "MBG1"
    tree "MBG1_REVISION1"
      sgroup "MBG1_REVISION1 (at 0x2c00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MBG1_REVISION2"
      sgroup "MBG1_REVISION2 (at 0x2c01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MBG1_REVISION3"
      sgroup "MBG1_REVISION3 (at 0x2c02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MBG1_REVISION4"
      sgroup "MBG1_REVISION4 (at 0x2c03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MBG1_PERPH_TYPE"
      sgroup "MBG1_PERPH_TYPE (at 0x2c04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MBG1_PERPH_SUBTYPE"
      sgroup "MBG1_PERPH_SUBTYPE (at 0x2c05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MBG1_STATUS1"
      sgroup "MBG1_STATUS1 (at 0x2c08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
    tree.end
    tree "MBG1_MODE_CTRL"
      sgroup "MBG1_MODE_CTRL (at 0x2c44)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_NPM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   NPM_FOLLOW_SLEEPB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_FASTVBG                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FORCE_MBGCC_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FORCE_IPTAT_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FORCE_IREF_EN                            = " "0, 1"
    tree.end
    tree "MBG1_EN_CTL"
      sgroup "MBG1_EN_CTL (at 0x2c46)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MBG_EN                                   = " "0, 1"
    tree.end
    tree "MBG1_SEC_ACCESS"
      sgroup "MBG1_SEC_ACCESS (at 0x2cd0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MBG1_PERPH_RESET_CTL1"
      sgroup "MBG1_PERPH_RESET_CTL1 (at 0x2cd8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL2"
      sgroup "MBG1_PERPH_RESET_CTL2 (at 0x2cd9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL3"
      sgroup "MBG1_PERPH_RESET_CTL3 (at 0x2cda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MBG1_PERPH_RESET_CTL4"
      sgroup "MBG1_PERPH_RESET_CTL4 (at 0x2cdb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "MBG1_TEST1"
      sgroup "MBG1_TEST1 (at 0x2ce2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   ATEST1                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ATEST2                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MBG1_TEST2"
      sgroup "MBG1_TEST2 (at 0x2ce3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802ce30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ce30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DIS_BUFFS                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DISCON_CAPS                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   OB_FAST_TRIM_MODE_EN                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MBG_CC_RES_TRIM                          = " "0, 1, 2, 3"
    tree.end
    tree "MBG1_TRIM_NUM"
      sgroup "MBG1_TRIM_NUM (at 0x2cf0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "MBG1_MBG_TRIM1"
      sgroup "MBG1_MBG_TRIM1 (at 0x2cf1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   VBG0_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM2"
      sgroup "MBG1_MBG_TRIM2 (at 0x2cf2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   ISLEEP_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM3"
      sgroup "MBG1_MBG_TRIM3 (at 0x2cf3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   IPTAT_TRIM                               = "
    tree.end
    tree "MBG1_MBG_TRIM4"
      sgroup "MBG1_MBG_TRIM4 (at 0x2cf4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   MBG_CC_TRIM                              = "
    tree.end
    tree "MBG1_MBG_TRIM5"
      sgroup "MBG1_MBG_TRIM5 (at 0x2cf5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   IREF_TRIM                                = "
    tree.end
    tree "MBG1_MBG_TRIM6"
      sgroup "MBG1_MBG_TRIM6 (at 0x2cf6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VBG1P25_TRIM                             = "
    tree.end
    tree "MBG1_MBG_TRIM7"
      sgroup "MBG1_MBG_TRIM7 (at 0x2cf7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P625_TRIM                            = "
    tree.end
    tree "MBG1_MBG_TRIM8"
      sgroup "MBG1_MBG_TRIM8 (at 0x2cf8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        set &access:&cmd_addr %l 0x802cf80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2cf80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VBG0P3125_TRIM                           = "
    tree.end
  tree.end
tree.end
tree "MISC"
  tree "MISC"
    tree "MISC_REVISION1"
      sgroup "MISC_REVISION1 (at 0x900)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MISC_REVISION2"
      sgroup "MISC_REVISION2 (at 0x901)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MISC_REVISION3"
      sgroup "MISC_REVISION3 (at 0x902)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MISC_REVISION4"
      sgroup "MISC_REVISION4 (at 0x903)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MISC_PERPH_TYPE"
      sgroup "MISC_PERPH_TYPE (at 0x904)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MISC_PERPH_SUBTYPE"
      sgroup "MISC_PERPH_SUBTYPE (at 0x905)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MISC_TEST_ACCESS"
      sgroup "MISC_TEST_ACCESS (at 0x940)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEST_ACCESS_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RFU                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_CONNECT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST_CONNECT_1                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST_CONNECT_0                          = " "0, 1"
    tree.end
    tree "MISC_XVDD_DVDD_SRC_CTL"
      sgroup "MISC_XVDD_DVDD_SRC_CTL (at 0x942)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   XVDD_DVDD_SRC_CTRL                       = " "0, 1, 2, 3"
    tree.end
    tree "MISC_SEC_ACCESS"
      sgroup "MISC_SEC_ACCESS (at 0x9d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MISC_PERPH_RESET_CTL2"
      sgroup "MISC_PERPH_RESET_CTL2 (at 0x9d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL3"
      sgroup "MISC_PERPH_RESET_CTL3 (at 0x9da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MISC_PERPH_RESET_CTL4"
      sgroup "MISC_PERPH_RESET_CTL4 (at 0x9db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        set &access:&cmd_addr %l 0x8009db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x9db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP1"
  tree "MPP1"
    tree "MPP1_REVISION1"
      sgroup "MPP1_REVISION1 (at 0xa000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP1_REVISION2"
      sgroup "MPP1_REVISION2 (at 0xa001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP1_REVISION3"
      sgroup "MPP1_REVISION3 (at 0xa002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP1_REVISION4"
      sgroup "MPP1_REVISION4 (at 0xa003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP1_PERPH_TYPE"
      sgroup "MPP1_PERPH_TYPE (at 0xa004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP1_PERPH_SUBTYPE"
      sgroup "MPP1_PERPH_SUBTYPE (at 0xa005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP1_STATUS1"
      sgroup "MPP1_STATUS1 (at 0xa008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP1_INT_RT_STS"
      sgroup "MPP1_INT_RT_STS (at 0xa010)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP1_INT_SET_TYPE"
      sgroup "MPP1_INT_SET_TYPE (at 0xa011)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP1_INT_POLARITY_HIGH"
      sgroup "MPP1_INT_POLARITY_HIGH (at 0xa012)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP1_INT_POLARITY_LOW"
      sgroup "MPP1_INT_POLARITY_LOW (at 0xa013)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP1_INT_LATCHED_CLR"
      sgroup "MPP1_INT_LATCHED_CLR (at 0xa014)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_SET"
      sgroup "MPP1_INT_EN_SET (at 0xa015)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP1_INT_EN_CLR"
      sgroup "MPP1_INT_EN_CLR (at 0xa016)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP1_INT_LATCHED_STS"
      sgroup "MPP1_INT_LATCHED_STS (at 0xa018)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP1_INT_PENDING_STS"
      sgroup "MPP1_INT_PENDING_STS (at 0xa019)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP1_INT_MID_SEL"
      sgroup "MPP1_INT_MID_SEL (at 0xa01a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP1_INT_PRIORITY"
      sgroup "MPP1_INT_PRIORITY (at 0xa01b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a01b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa01b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP1_MODE_CTL"
      sgroup "MPP1_MODE_CTL (at 0xa040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP1_DIG_VIN_CTL"
      sgroup "MPP1_DIG_VIN_CTL (at 0xa041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_DIG_PULL_CTL"
      sgroup "MPP1_DIG_PULL_CTL (at 0xa042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_DIG_IN_CTL"
      sgroup "MPP1_DIG_IN_CTL (at 0xa043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP1_EN_CTL"
      sgroup "MPP1_EN_CTL (at 0xa046)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP1_ANA_OUT_CTL"
      sgroup "MPP1_ANA_OUT_CTL (at 0xa048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_ANA_IN_CTL"
      sgroup "MPP1_ANA_IN_CTL (at 0xa04a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_SINK_CTL"
      sgroup "MPP1_SINK_CTL (at 0xa04c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a04c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa04c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP1_SEC_ACCESS"
      sgroup "MPP1_SEC_ACCESS (at 0xa0d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP1_PERPH_RESET_CTL1"
      sgroup "MPP1_PERPH_RESET_CTL1 (at 0xa0d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP1_PERPH_RESET_CTL2"
      sgroup "MPP1_PERPH_RESET_CTL2 (at 0xa0d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP1_PERPH_RESET_CTL3"
      sgroup "MPP1_PERPH_RESET_CTL3 (at 0xa0da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP1_PERPH_RESET_CTL4"
      sgroup "MPP1_PERPH_RESET_CTL4 (at 0xa0db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        set &access:&cmd_addr %l 0x80a0db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa0db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP2"
  tree "MPP2"
    tree "MPP2_REVISION1"
      sgroup "MPP2_REVISION1 (at 0xa100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP2_REVISION2"
      sgroup "MPP2_REVISION2 (at 0xa101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP2_REVISION3"
      sgroup "MPP2_REVISION3 (at 0xa102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP2_REVISION4"
      sgroup "MPP2_REVISION4 (at 0xa103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP2_PERPH_TYPE"
      sgroup "MPP2_PERPH_TYPE (at 0xa104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP2_PERPH_SUBTYPE"
      sgroup "MPP2_PERPH_SUBTYPE (at 0xa105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP2_STATUS1"
      sgroup "MPP2_STATUS1 (at 0xa108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP2_INT_RT_STS"
      sgroup "MPP2_INT_RT_STS (at 0xa110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP2_INT_SET_TYPE"
      sgroup "MPP2_INT_SET_TYPE (at 0xa111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP2_INT_POLARITY_HIGH"
      sgroup "MPP2_INT_POLARITY_HIGH (at 0xa112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP2_INT_POLARITY_LOW"
      sgroup "MPP2_INT_POLARITY_LOW (at 0xa113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP2_INT_LATCHED_CLR"
      sgroup "MPP2_INT_LATCHED_CLR (at 0xa114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_SET"
      sgroup "MPP2_INT_EN_SET (at 0xa115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP2_INT_EN_CLR"
      sgroup "MPP2_INT_EN_CLR (at 0xa116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP2_INT_LATCHED_STS"
      sgroup "MPP2_INT_LATCHED_STS (at 0xa118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP2_INT_PENDING_STS"
      sgroup "MPP2_INT_PENDING_STS (at 0xa119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP2_INT_MID_SEL"
      sgroup "MPP2_INT_MID_SEL (at 0xa11a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP2_INT_PRIORITY"
      sgroup "MPP2_INT_PRIORITY (at 0xa11b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a11b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa11b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP2_MODE_CTL"
      sgroup "MPP2_MODE_CTL (at 0xa140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP2_DIG_VIN_CTL"
      sgroup "MPP2_DIG_VIN_CTL (at 0xa141)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_DIG_PULL_CTL"
      sgroup "MPP2_DIG_PULL_CTL (at 0xa142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_DIG_IN_CTL"
      sgroup "MPP2_DIG_IN_CTL (at 0xa143)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP2_EN_CTL"
      sgroup "MPP2_EN_CTL (at 0xa146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP2_ANA_OUT_CTL"
      sgroup "MPP2_ANA_OUT_CTL (at 0xa148)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_ANA_IN_CTL"
      sgroup "MPP2_ANA_IN_CTL (at 0xa14a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_SINK_CTL"
      sgroup "MPP2_SINK_CTL (at 0xa14c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a14c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa14c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP2_SEC_ACCESS"
      sgroup "MPP2_SEC_ACCESS (at 0xa1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP2_PERPH_RESET_CTL1"
      sgroup "MPP2_PERPH_RESET_CTL1 (at 0xa1d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP2_PERPH_RESET_CTL2"
      sgroup "MPP2_PERPH_RESET_CTL2 (at 0xa1d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP2_PERPH_RESET_CTL3"
      sgroup "MPP2_PERPH_RESET_CTL3 (at 0xa1da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP2_PERPH_RESET_CTL4"
      sgroup "MPP2_PERPH_RESET_CTL4 (at 0xa1db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        set &access:&cmd_addr %l 0x80a1db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa1db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP3"
  tree "MPP3"
    tree "MPP3_REVISION1"
      sgroup "MPP3_REVISION1 (at 0xa200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP3_REVISION2"
      sgroup "MPP3_REVISION2 (at 0xa201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP3_REVISION3"
      sgroup "MPP3_REVISION3 (at 0xa202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP3_REVISION4"
      sgroup "MPP3_REVISION4 (at 0xa203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP3_PERPH_TYPE"
      sgroup "MPP3_PERPH_TYPE (at 0xa204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP3_PERPH_SUBTYPE"
      sgroup "MPP3_PERPH_SUBTYPE (at 0xa205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP3_STATUS1"
      sgroup "MPP3_STATUS1 (at 0xa208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP3_INT_RT_STS"
      sgroup "MPP3_INT_RT_STS (at 0xa210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP3_INT_SET_TYPE"
      sgroup "MPP3_INT_SET_TYPE (at 0xa211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP3_INT_POLARITY_HIGH"
      sgroup "MPP3_INT_POLARITY_HIGH (at 0xa212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP3_INT_POLARITY_LOW"
      sgroup "MPP3_INT_POLARITY_LOW (at 0xa213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP3_INT_LATCHED_CLR"
      sgroup "MPP3_INT_LATCHED_CLR (at 0xa214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_SET"
      sgroup "MPP3_INT_EN_SET (at 0xa215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP3_INT_EN_CLR"
      sgroup "MPP3_INT_EN_CLR (at 0xa216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP3_INT_LATCHED_STS"
      sgroup "MPP3_INT_LATCHED_STS (at 0xa218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP3_INT_PENDING_STS"
      sgroup "MPP3_INT_PENDING_STS (at 0xa219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP3_INT_MID_SEL"
      sgroup "MPP3_INT_MID_SEL (at 0xa21a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP3_INT_PRIORITY"
      sgroup "MPP3_INT_PRIORITY (at 0xa21b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a21b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa21b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP3_MODE_CTL"
      sgroup "MPP3_MODE_CTL (at 0xa240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP3_DIG_VIN_CTL"
      sgroup "MPP3_DIG_VIN_CTL (at 0xa241)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_DIG_PULL_CTL"
      sgroup "MPP3_DIG_PULL_CTL (at 0xa242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_DIG_IN_CTL"
      sgroup "MPP3_DIG_IN_CTL (at 0xa243)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP3_EN_CTL"
      sgroup "MPP3_EN_CTL (at 0xa246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP3_ANA_OUT_CTL"
      sgroup "MPP3_ANA_OUT_CTL (at 0xa248)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_ANA_IN_CTL"
      sgroup "MPP3_ANA_IN_CTL (at 0xa24a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_SINK_CTL"
      sgroup "MPP3_SINK_CTL (at 0xa24c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a24c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa24c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP3_SEC_ACCESS"
      sgroup "MPP3_SEC_ACCESS (at 0xa2d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP3_PERPH_RESET_CTL1"
      sgroup "MPP3_PERPH_RESET_CTL1 (at 0xa2d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP3_PERPH_RESET_CTL2"
      sgroup "MPP3_PERPH_RESET_CTL2 (at 0xa2d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP3_PERPH_RESET_CTL3"
      sgroup "MPP3_PERPH_RESET_CTL3 (at 0xa2da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP3_PERPH_RESET_CTL4"
      sgroup "MPP3_PERPH_RESET_CTL4 (at 0xa2db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        set &access:&cmd_addr %l 0x80a2db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa2db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "MPP4"
  tree "MPP4"
    tree "MPP4_REVISION1"
      sgroup "MPP4_REVISION1 (at 0xa300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "MPP4_REVISION2"
      sgroup "MPP4_REVISION2 (at 0xa301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "MPP4_REVISION3"
      sgroup "MPP4_REVISION3 (at 0xa302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "MPP4_REVISION4"
      sgroup "MPP4_REVISION4 (at 0xa303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "MPP4_PERPH_TYPE"
      sgroup "MPP4_PERPH_TYPE (at 0xa304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "MPP4_PERPH_SUBTYPE"
      sgroup "MPP4_PERPH_SUBTYPE (at 0xa305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "MPP4_STATUS1"
      sgroup "MPP4_STATUS1 (at 0xa308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MPP_OK                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_VAL                                  = " "0, 1"
    tree.end
    tree "MPP4_INT_RT_STS"
      sgroup "MPP4_INT_RT_STS (at 0xa310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_STS                               = " "0, 1"
    tree.end
    tree "MPP4_INT_SET_TYPE"
      sgroup "MPP4_INT_SET_TYPE (at 0xa311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_TYPE                              = " "0, 1"
    tree.end
    tree "MPP4_INT_POLARITY_HIGH"
      sgroup "MPP4_INT_POLARITY_HIGH (at 0xa312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_HIGH                              = " "0, 1"
    tree.end
    tree "MPP4_INT_POLARITY_LOW"
      sgroup "MPP4_INT_POLARITY_LOW (at 0xa313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LOW                               = " "0, 1"
    tree.end
    tree "MPP4_INT_LATCHED_CLR"
      sgroup "MPP4_INT_LATCHED_CLR (at 0xa314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_CLR                       = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_SET"
      sgroup "MPP4_INT_EN_SET (at 0xa315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_SET                            = " "0, 1"
    tree.end
    tree "MPP4_INT_EN_CLR"
      sgroup "MPP4_INT_EN_CLR (at 0xa316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_EN_CLR                            = " "0, 1"
    tree.end
    tree "MPP4_INT_LATCHED_STS"
      sgroup "MPP4_INT_LATCHED_STS (at 0xa318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_LATCHED_STS                       = " "0, 1"
    tree.end
    tree "MPP4_INT_PENDING_STS"
      sgroup "MPP4_INT_PENDING_STS (at 0xa319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MPP_IN_PENDING_STS                       = " "0, 1"
    tree.end
    tree "MPP4_INT_MID_SEL"
      sgroup "MPP4_INT_MID_SEL (at 0xa31a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "MPP4_INT_PRIORITY"
      sgroup "MPP4_INT_PRIORITY (at 0xa31b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a31b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa31b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "MPP4_MODE_CTL"
      sgroup "MPP4_MODE_CTL (at 0xa340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   MODE                                     = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   EN_AND_SOURCE_SEL                        = "
    tree.end
    tree "MPP4_DIG_VIN_CTL"
      sgroup "MPP4_DIG_VIN_CTL (at 0xa341)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VOLTAGE_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_DIG_PULL_CTL"
      sgroup "MPP4_DIG_PULL_CTL (at 0xa342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PULLUP_SEL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_DIG_IN_CTL"
      sgroup "MPP4_DIG_IN_CTL (at 0xa343)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST4                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   DTEST2                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DTEST1                                   = " "0, 1"
    tree.end
    tree "MPP4_EN_CTL"
      sgroup "MPP4_EN_CTL (at 0xa346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "MPP4_ANA_OUT_CTL"
      sgroup "MPP4_ANA_OUT_CTL (at 0xa348)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   REF_SEL                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_ANA_IN_CTL"
      sgroup "MPP4_ANA_IN_CTL (at 0xa34a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   ROUTE_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_SINK_CTL"
      sgroup "MPP4_SINK_CTL (at 0xa34c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a34c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa34c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_SEL                              = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "MPP4_SEC_ACCESS"
      sgroup "MPP4_SEC_ACCESS (at 0xa3d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "MPP4_PERPH_RESET_CTL1"
      sgroup "MPP4_PERPH_RESET_CTL1 (at 0xa3d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "MPP4_PERPH_RESET_CTL2"
      sgroup "MPP4_PERPH_RESET_CTL2 (at 0xa3d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "MPP4_PERPH_RESET_CTL3"
      sgroup "MPP4_PERPH_RESET_CTL3 (at 0xa3da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "MPP4_PERPH_RESET_CTL4"
      sgroup "MPP4_PERPH_RESET_CTL4 (at 0xa3db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        set &access:&cmd_addr %l 0x80a3db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xa300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xa3db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT0"
  tree "PBS_CLIENT0"
    tree "PBS_CLIENT0_REVISION1"
      sgroup "PBS_CLIENT0_REVISION1 (at 0x7100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION2"
      sgroup "PBS_CLIENT0_REVISION2 (at 0x7101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION3"
      sgroup "PBS_CLIENT0_REVISION3 (at 0x7102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT0_REVISION4"
      sgroup "PBS_CLIENT0_REVISION4 (at 0x7103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT0_PERPH_TYPE"
      sgroup "PBS_CLIENT0_PERPH_TYPE (at 0x7104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT0_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT0_PERPH_SUBTYPE (at 0x7105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT0_STATUS0"
      sgroup "PBS_CLIENT0_STATUS0 (at 0x7108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT0_INT_RT_STS"
      sgroup "PBS_CLIENT0_INT_RT_STS (at 0x7110)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_SET_TYPE"
      sgroup "PBS_CLIENT0_INT_SET_TYPE (at 0x7111)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT0_INT_POLARITY_HIGH (at 0x7112)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT0_INT_POLARITY_LOW (at 0x7113)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT0_INT_LATCHED_CLR (at 0x7114)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_SET"
      sgroup "PBS_CLIENT0_INT_EN_SET (at 0x7115)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_EN_CLR"
      sgroup "PBS_CLIENT0_INT_EN_CLR (at 0x7116)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_LATCHED_STS"
      sgroup "PBS_CLIENT0_INT_LATCHED_STS (at 0x7118)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_PENDING_STS"
      sgroup "PBS_CLIENT0_INT_PENDING_STS (at 0x7119)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_MID_SEL"
      sgroup "PBS_CLIENT0_INT_MID_SEL (at 0x711a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT0_INT_PRIORITY"
      sgroup "PBS_CLIENT0_INT_PRIORITY (at 0x711b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x80711b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x711b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CFG"
      sgroup "PBS_CLIENT0_TRIG_CFG (at 0x7140)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_TRIG_CTL"
      sgroup "PBS_CLIENT0_TRIG_CTL (at 0x7142)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_EN_CTL"
      sgroup "PBS_CLIENT0_EN_CTL (at 0x7146)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_SEC_ACCESS"
      sgroup "PBS_CLIENT0_SEC_ACCESS (at 0x71d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL1 (at 0x71d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL2 (at 0x71d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL3 (at 0x71da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT0_PERPH_RESET_CTL4 (at 0x71db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_TEST1"
      sgroup "PBS_CLIENT0_INT_TEST1 (at 0x71e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT0_INT_TEST_VAL"
      sgroup "PBS_CLIENT0_INT_TEST_VAL (at 0x71e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        set &access:&cmd_addr %l 0x8071e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x71e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT1"
  tree "PBS_CLIENT1"
    tree "PBS_CLIENT1_REVISION1"
      sgroup "PBS_CLIENT1_REVISION1 (at 0x7200)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION2"
      sgroup "PBS_CLIENT1_REVISION2 (at 0x7201)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION3"
      sgroup "PBS_CLIENT1_REVISION3 (at 0x7202)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT1_REVISION4"
      sgroup "PBS_CLIENT1_REVISION4 (at 0x7203)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT1_PERPH_TYPE"
      sgroup "PBS_CLIENT1_PERPH_TYPE (at 0x7204)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT1_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT1_PERPH_SUBTYPE (at 0x7205)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT1_STATUS0"
      sgroup "PBS_CLIENT1_STATUS0 (at 0x7208)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT1_INT_RT_STS"
      sgroup "PBS_CLIENT1_INT_RT_STS (at 0x7210)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_SET_TYPE"
      sgroup "PBS_CLIENT1_INT_SET_TYPE (at 0x7211)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT1_INT_POLARITY_HIGH (at 0x7212)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT1_INT_POLARITY_LOW (at 0x7213)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT1_INT_LATCHED_CLR (at 0x7214)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_SET"
      sgroup "PBS_CLIENT1_INT_EN_SET (at 0x7215)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_EN_CLR"
      sgroup "PBS_CLIENT1_INT_EN_CLR (at 0x7216)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_LATCHED_STS"
      sgroup "PBS_CLIENT1_INT_LATCHED_STS (at 0x7218)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_PENDING_STS"
      sgroup "PBS_CLIENT1_INT_PENDING_STS (at 0x7219)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_MID_SEL"
      sgroup "PBS_CLIENT1_INT_MID_SEL (at 0x721a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT1_INT_PRIORITY"
      sgroup "PBS_CLIENT1_INT_PRIORITY (at 0x721b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x80721b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x721b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CFG"
      sgroup "PBS_CLIENT1_TRIG_CFG (at 0x7240)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_TRIG_CTL"
      sgroup "PBS_CLIENT1_TRIG_CTL (at 0x7242)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_EN_CTL"
      sgroup "PBS_CLIENT1_EN_CTL (at 0x7246)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_SEC_ACCESS"
      sgroup "PBS_CLIENT1_SEC_ACCESS (at 0x72d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL1 (at 0x72d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL2 (at 0x72d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL3 (at 0x72da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT1_PERPH_RESET_CTL4 (at 0x72db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_TEST1"
      sgroup "PBS_CLIENT1_INT_TEST1 (at 0x72e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT1_INT_TEST_VAL"
      sgroup "PBS_CLIENT1_INT_TEST_VAL (at 0x72e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        set &access:&cmd_addr %l 0x8072e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x72e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT2"
  tree "PBS_CLIENT2"
    tree "PBS_CLIENT2_REVISION1"
      sgroup "PBS_CLIENT2_REVISION1 (at 0x7300)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION2"
      sgroup "PBS_CLIENT2_REVISION2 (at 0x7301)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION3"
      sgroup "PBS_CLIENT2_REVISION3 (at 0x7302)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT2_REVISION4"
      sgroup "PBS_CLIENT2_REVISION4 (at 0x7303)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT2_PERPH_TYPE"
      sgroup "PBS_CLIENT2_PERPH_TYPE (at 0x7304)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT2_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT2_PERPH_SUBTYPE (at 0x7305)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT2_STATUS0"
      sgroup "PBS_CLIENT2_STATUS0 (at 0x7308)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT2_INT_RT_STS"
      sgroup "PBS_CLIENT2_INT_RT_STS (at 0x7310)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_SET_TYPE"
      sgroup "PBS_CLIENT2_INT_SET_TYPE (at 0x7311)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT2_INT_POLARITY_HIGH (at 0x7312)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT2_INT_POLARITY_LOW (at 0x7313)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT2_INT_LATCHED_CLR (at 0x7314)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_SET"
      sgroup "PBS_CLIENT2_INT_EN_SET (at 0x7315)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_EN_CLR"
      sgroup "PBS_CLIENT2_INT_EN_CLR (at 0x7316)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_LATCHED_STS"
      sgroup "PBS_CLIENT2_INT_LATCHED_STS (at 0x7318)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_PENDING_STS"
      sgroup "PBS_CLIENT2_INT_PENDING_STS (at 0x7319)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_MID_SEL"
      sgroup "PBS_CLIENT2_INT_MID_SEL (at 0x731a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT2_INT_PRIORITY"
      sgroup "PBS_CLIENT2_INT_PRIORITY (at 0x731b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x80731b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x731b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CFG"
      sgroup "PBS_CLIENT2_TRIG_CFG (at 0x7340)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_TRIG_CTL"
      sgroup "PBS_CLIENT2_TRIG_CTL (at 0x7342)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_EN_CTL"
      sgroup "PBS_CLIENT2_EN_CTL (at 0x7346)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_SEC_ACCESS"
      sgroup "PBS_CLIENT2_SEC_ACCESS (at 0x73d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL1 (at 0x73d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL2 (at 0x73d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL3 (at 0x73da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT2_PERPH_RESET_CTL4 (at 0x73db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_TEST1"
      sgroup "PBS_CLIENT2_INT_TEST1 (at 0x73e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT2_INT_TEST_VAL"
      sgroup "PBS_CLIENT2_INT_TEST_VAL (at 0x73e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        set &access:&cmd_addr %l 0x8073e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x73e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT3"
  tree "PBS_CLIENT3"
    tree "PBS_CLIENT3_REVISION1"
      sgroup "PBS_CLIENT3_REVISION1 (at 0x7400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION2"
      sgroup "PBS_CLIENT3_REVISION2 (at 0x7401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION3"
      sgroup "PBS_CLIENT3_REVISION3 (at 0x7402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT3_REVISION4"
      sgroup "PBS_CLIENT3_REVISION4 (at 0x7403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT3_PERPH_TYPE"
      sgroup "PBS_CLIENT3_PERPH_TYPE (at 0x7404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT3_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT3_PERPH_SUBTYPE (at 0x7405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT3_STATUS0"
      sgroup "PBS_CLIENT3_STATUS0 (at 0x7408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT3_INT_RT_STS"
      sgroup "PBS_CLIENT3_INT_RT_STS (at 0x7410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_SET_TYPE"
      sgroup "PBS_CLIENT3_INT_SET_TYPE (at 0x7411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT3_INT_POLARITY_HIGH (at 0x7412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT3_INT_POLARITY_LOW (at 0x7413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT3_INT_LATCHED_CLR (at 0x7414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_SET"
      sgroup "PBS_CLIENT3_INT_EN_SET (at 0x7415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_EN_CLR"
      sgroup "PBS_CLIENT3_INT_EN_CLR (at 0x7416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_LATCHED_STS"
      sgroup "PBS_CLIENT3_INT_LATCHED_STS (at 0x7418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_PENDING_STS"
      sgroup "PBS_CLIENT3_INT_PENDING_STS (at 0x7419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_MID_SEL"
      sgroup "PBS_CLIENT3_INT_MID_SEL (at 0x741a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT3_INT_PRIORITY"
      sgroup "PBS_CLIENT3_INT_PRIORITY (at 0x741b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x80741b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x741b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CFG"
      sgroup "PBS_CLIENT3_TRIG_CFG (at 0x7440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_TRIG_CTL"
      sgroup "PBS_CLIENT3_TRIG_CTL (at 0x7442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_EN_CTL"
      sgroup "PBS_CLIENT3_EN_CTL (at 0x7446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_SEC_ACCESS"
      sgroup "PBS_CLIENT3_SEC_ACCESS (at 0x74d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL1 (at 0x74d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL2 (at 0x74d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL3 (at 0x74da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT3_PERPH_RESET_CTL4 (at 0x74db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_TEST1"
      sgroup "PBS_CLIENT3_INT_TEST1 (at 0x74e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT3_INT_TEST_VAL"
      sgroup "PBS_CLIENT3_INT_TEST_VAL (at 0x74e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        set &access:&cmd_addr %l 0x8074e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x74e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT4"
  tree "PBS_CLIENT4"
    tree "PBS_CLIENT4_REVISION1"
      sgroup "PBS_CLIENT4_REVISION1 (at 0x7500)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION2"
      sgroup "PBS_CLIENT4_REVISION2 (at 0x7501)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION3"
      sgroup "PBS_CLIENT4_REVISION3 (at 0x7502)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT4_REVISION4"
      sgroup "PBS_CLIENT4_REVISION4 (at 0x7503)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT4_PERPH_TYPE"
      sgroup "PBS_CLIENT4_PERPH_TYPE (at 0x7504)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT4_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT4_PERPH_SUBTYPE (at 0x7505)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT4_STATUS0"
      sgroup "PBS_CLIENT4_STATUS0 (at 0x7508)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT4_INT_RT_STS"
      sgroup "PBS_CLIENT4_INT_RT_STS (at 0x7510)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_SET_TYPE"
      sgroup "PBS_CLIENT4_INT_SET_TYPE (at 0x7511)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT4_INT_POLARITY_HIGH (at 0x7512)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT4_INT_POLARITY_LOW (at 0x7513)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT4_INT_LATCHED_CLR (at 0x7514)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_SET"
      sgroup "PBS_CLIENT4_INT_EN_SET (at 0x7515)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_EN_CLR"
      sgroup "PBS_CLIENT4_INT_EN_CLR (at 0x7516)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_LATCHED_STS"
      sgroup "PBS_CLIENT4_INT_LATCHED_STS (at 0x7518)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_PENDING_STS"
      sgroup "PBS_CLIENT4_INT_PENDING_STS (at 0x7519)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_MID_SEL"
      sgroup "PBS_CLIENT4_INT_MID_SEL (at 0x751a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT4_INT_PRIORITY"
      sgroup "PBS_CLIENT4_INT_PRIORITY (at 0x751b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x80751b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x751b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CFG"
      sgroup "PBS_CLIENT4_TRIG_CFG (at 0x7540)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_TRIG_CTL"
      sgroup "PBS_CLIENT4_TRIG_CTL (at 0x7542)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_EN_CTL"
      sgroup "PBS_CLIENT4_EN_CTL (at 0x7546)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_SEC_ACCESS"
      sgroup "PBS_CLIENT4_SEC_ACCESS (at 0x75d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL1 (at 0x75d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL2 (at 0x75d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL3 (at 0x75da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT4_PERPH_RESET_CTL4 (at 0x75db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_TEST1"
      sgroup "PBS_CLIENT4_INT_TEST1 (at 0x75e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT4_INT_TEST_VAL"
      sgroup "PBS_CLIENT4_INT_TEST_VAL (at 0x75e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        set &access:&cmd_addr %l 0x8075e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x75e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT5"
  tree "PBS_CLIENT5"
    tree "PBS_CLIENT5_REVISION1"
      sgroup "PBS_CLIENT5_REVISION1 (at 0x7600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION2"
      sgroup "PBS_CLIENT5_REVISION2 (at 0x7601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION3"
      sgroup "PBS_CLIENT5_REVISION3 (at 0x7602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT5_REVISION4"
      sgroup "PBS_CLIENT5_REVISION4 (at 0x7603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT5_PERPH_TYPE"
      sgroup "PBS_CLIENT5_PERPH_TYPE (at 0x7604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT5_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT5_PERPH_SUBTYPE (at 0x7605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT5_STATUS0"
      sgroup "PBS_CLIENT5_STATUS0 (at 0x7608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT5_INT_RT_STS"
      sgroup "PBS_CLIENT5_INT_RT_STS (at 0x7610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_SET_TYPE"
      sgroup "PBS_CLIENT5_INT_SET_TYPE (at 0x7611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT5_INT_POLARITY_HIGH (at 0x7612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT5_INT_POLARITY_LOW (at 0x7613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT5_INT_LATCHED_CLR (at 0x7614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_SET"
      sgroup "PBS_CLIENT5_INT_EN_SET (at 0x7615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_EN_CLR"
      sgroup "PBS_CLIENT5_INT_EN_CLR (at 0x7616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_LATCHED_STS"
      sgroup "PBS_CLIENT5_INT_LATCHED_STS (at 0x7618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_PENDING_STS"
      sgroup "PBS_CLIENT5_INT_PENDING_STS (at 0x7619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_MID_SEL"
      sgroup "PBS_CLIENT5_INT_MID_SEL (at 0x761a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT5_INT_PRIORITY"
      sgroup "PBS_CLIENT5_INT_PRIORITY (at 0x761b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x80761b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x761b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CFG"
      sgroup "PBS_CLIENT5_TRIG_CFG (at 0x7640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_TRIG_CTL"
      sgroup "PBS_CLIENT5_TRIG_CTL (at 0x7642)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_EN_CTL"
      sgroup "PBS_CLIENT5_EN_CTL (at 0x7646)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_SEC_ACCESS"
      sgroup "PBS_CLIENT5_SEC_ACCESS (at 0x76d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL1 (at 0x76d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL2 (at 0x76d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL3 (at 0x76da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT5_PERPH_RESET_CTL4 (at 0x76db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_TEST1"
      sgroup "PBS_CLIENT5_INT_TEST1 (at 0x76e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT5_INT_TEST_VAL"
      sgroup "PBS_CLIENT5_INT_TEST_VAL (at 0x76e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        set &access:&cmd_addr %l 0x8076e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x76e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT6"
  tree "PBS_CLIENT6"
    tree "PBS_CLIENT6_REVISION1"
      sgroup "PBS_CLIENT6_REVISION1 (at 0x7700)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION2"
      sgroup "PBS_CLIENT6_REVISION2 (at 0x7701)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION3"
      sgroup "PBS_CLIENT6_REVISION3 (at 0x7702)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT6_REVISION4"
      sgroup "PBS_CLIENT6_REVISION4 (at 0x7703)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT6_PERPH_TYPE"
      sgroup "PBS_CLIENT6_PERPH_TYPE (at 0x7704)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT6_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT6_PERPH_SUBTYPE (at 0x7705)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT6_STATUS0"
      sgroup "PBS_CLIENT6_STATUS0 (at 0x7708)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT6_INT_RT_STS"
      sgroup "PBS_CLIENT6_INT_RT_STS (at 0x7710)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_SET_TYPE"
      sgroup "PBS_CLIENT6_INT_SET_TYPE (at 0x7711)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT6_INT_POLARITY_HIGH (at 0x7712)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT6_INT_POLARITY_LOW (at 0x7713)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT6_INT_LATCHED_CLR (at 0x7714)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_SET"
      sgroup "PBS_CLIENT6_INT_EN_SET (at 0x7715)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_EN_CLR"
      sgroup "PBS_CLIENT6_INT_EN_CLR (at 0x7716)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_LATCHED_STS"
      sgroup "PBS_CLIENT6_INT_LATCHED_STS (at 0x7718)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_PENDING_STS"
      sgroup "PBS_CLIENT6_INT_PENDING_STS (at 0x7719)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_MID_SEL"
      sgroup "PBS_CLIENT6_INT_MID_SEL (at 0x771a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT6_INT_PRIORITY"
      sgroup "PBS_CLIENT6_INT_PRIORITY (at 0x771b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x80771b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x771b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CFG"
      sgroup "PBS_CLIENT6_TRIG_CFG (at 0x7740)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_TRIG_CTL"
      sgroup "PBS_CLIENT6_TRIG_CTL (at 0x7742)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_EN_CTL"
      sgroup "PBS_CLIENT6_EN_CTL (at 0x7746)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_SEC_ACCESS"
      sgroup "PBS_CLIENT6_SEC_ACCESS (at 0x77d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL1 (at 0x77d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL2 (at 0x77d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL3 (at 0x77da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT6_PERPH_RESET_CTL4 (at 0x77db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_TEST1"
      sgroup "PBS_CLIENT6_INT_TEST1 (at 0x77e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT6_INT_TEST_VAL"
      sgroup "PBS_CLIENT6_INT_TEST_VAL (at 0x77e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        set &access:&cmd_addr %l 0x8077e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x77e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CLIENT7"
  tree "PBS_CLIENT7"
    tree "PBS_CLIENT7_REVISION1"
      sgroup "PBS_CLIENT7_REVISION1 (at 0x7800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION2"
      sgroup "PBS_CLIENT7_REVISION2 (at 0x7801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION3"
      sgroup "PBS_CLIENT7_REVISION3 (at 0x7802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CLIENT7_REVISION4"
      sgroup "PBS_CLIENT7_REVISION4 (at 0x7803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CLIENT7_PERPH_TYPE"
      sgroup "PBS_CLIENT7_PERPH_TYPE (at 0x7804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CLIENT7_PERPH_SUBTYPE"
      sgroup "PBS_CLIENT7_PERPH_SUBTYPE (at 0x7805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CLIENT7_STATUS0"
      sgroup "PBS_CLIENT7_STATUS0 (at 0x7808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIG_EN_STATUS                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   COMP_STATUS                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   TRIG_FSM_STATUS                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PBS_CLIENT7_INT_RT_STS"
      sgroup "PBS_CLIENT7_INT_RT_STS (at 0x7810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_RT_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_RT_STS                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_SET_TYPE"
      sgroup "PBS_CLIENT7_INT_SET_TYPE (at 0x7811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TYPE                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TYPE                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_HIGH"
      sgroup "PBS_CLIENT7_INT_POLARITY_HIGH (at 0x7812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_HIGH                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_HIGH                           = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_POLARITY_LOW"
      sgroup "PBS_CLIENT7_INT_POLARITY_LOW (at 0x7813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LOW                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LOW                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_CLR"
      sgroup "PBS_CLIENT7_INT_LATCHED_CLR (at 0x7814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_CLR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_CLR                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_SET"
      sgroup "PBS_CLIENT7_INT_EN_SET (at 0x7815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_SET                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_SET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_EN_CLR"
      sgroup "PBS_CLIENT7_INT_EN_CLR (at 0x7816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_EN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_EN_CLR                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_LATCHED_STS"
      sgroup "PBS_CLIENT7_INT_LATCHED_STS (at 0x7818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_LATCHED_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_LATCHED_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_PENDING_STS"
      sgroup "PBS_CLIENT7_INT_PENDING_STS (at 0x7819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_PENDING_STS                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_PENDING_STS                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_MID_SEL"
      sgroup "PBS_CLIENT7_INT_MID_SEL (at 0x781a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x80781a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x781a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CLIENT7_INT_PRIORITY"
      sgroup "PBS_CLIENT7_INT_PRIORITY (at 0x781b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x80781b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x781b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CFG"
      sgroup "PBS_CLIENT7_TRIG_CFG (at 0x7840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_RE_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   TRIGGER_FE_EN                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_TRIG_CTL"
      sgroup "PBS_CLIENT7_TRIG_CTL (at 0x7842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIGGER                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_EN_CTL"
      sgroup "PBS_CLIENT7_EN_CTL (at 0x7846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TRIGGER_EN                               = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_SEC_ACCESS"
      sgroup "PBS_CLIENT7_SEC_ACCESS (at 0x78d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL1"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL1 (at 0x78d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL2"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL2 (at 0x78d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL3"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL3 (at 0x78da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_PERPH_RESET_CTL4"
      sgroup "PBS_CLIENT7_PERPH_RESET_CTL4 (at 0x78db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_TEST1"
      sgroup "PBS_CLIENT7_INT_TEST1 (at 0x78e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PBS_CLIENT7_INT_TEST_VAL"
      sgroup "PBS_CLIENT7_INT_TEST_VAL (at 0x78e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        set &access:&cmd_addr %l 0x8078e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x78e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SEQ_ENDED_TEST_VAL                       = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SEQ_ERROR_TEST_VAL                       = " "0, 1"
    tree.end
  tree.end
tree.end
tree "PBS_CORE"
  tree "PBS_CORE"
    tree "PBS_CORE_REVISION1"
      sgroup "PBS_CORE_REVISION1 (at 0x7000)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION2"
      sgroup "PBS_CORE_REVISION2 (at 0x7001)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PBS_CORE_REVISION3"
      sgroup "PBS_CORE_REVISION3 (at 0x7002)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PBS_CORE_REVISION4"
      sgroup "PBS_CORE_REVISION4 (at 0x7003)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PBS_CORE_PERPH_TYPE"
      sgroup "PBS_CORE_PERPH_TYPE (at 0x7004)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PBS_CORE_PERPH_SUBTYPE"
      sgroup "PBS_CORE_PERPH_SUBTYPE (at 0x7005)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS0"
      sgroup "PBS_CORE_SEQ_STATUS0 (at 0x7008)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   LAST_SEQ_COMP_STATUS                     = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_COMP                            = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_PC_STATUS0 (at 0x700a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_LSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_PC_STATUS1 (at 0x700b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PC_MSB                                   = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_IR_STATUS0 (at 0x700c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE0                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_IR_STATUS1 (at 0x700d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE1                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_IR_STATUS2 (at 0x700e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE2                                 = "
    tree.end
    tree "PBS_CORE_SEQ_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_IR_STATUS3 (at 0x700f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80700f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x700f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   IR_BYTE3                                 = "
    tree.end
    tree "PBS_CORE_MEM_INTF_CFG"
      sgroup "PBS_CORE_MEM_INTF_CFG (at 0x7040)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   RIF_MEM_ACCESS_EN                        = " "0, 1"
    tree.end
    tree "PBS_CORE_MEM_INTF_CTL"
      sgroup "PBS_CORE_MEM_INTF_CTL (at 0x7041)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   BURST                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WR_EN                                    = " "0, 1"
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_LSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_LSB (at 0x7042)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_LSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_ADDR_MSB"
      sgroup "PBS_CORE_MEM_INTF_ADDR_MSB (at 0x7043)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070430
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70430
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_ADDR_MSB                        = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA0"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA0 (at 0x7048)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA1"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA1 (at 0x7049)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA2"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA2 (at 0x704a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_WR_DATA3"
      sgroup "PBS_CORE_MEM_INTF_WR_DATA3 (at 0x704b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_WR_DATA_3                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA0"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA0 (at 0x704c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_0                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA1"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA1 (at 0x704d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_1                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA2"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA2 (at 0x704e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_2                       = "
    tree.end
    tree "PBS_CORE_MEM_INTF_RD_DATA3"
      sgroup "PBS_CORE_MEM_INTF_RD_DATA3 (at 0x704f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80704f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x704f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MEM_INTF_RD_DATA_3                       = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_LSB (at 0x7050)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG0_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG0_START_ADDR_MSB (at 0x7051)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_LSB (at 0x7054)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG1_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG1_START_ADDR_MSB (at 0x7055)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_LSB (at 0x7058)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG2_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG2_START_ADDR_MSB (at 0x7059)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_LSB (at 0x705c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG3_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG3_START_ADDR_MSB (at 0x705d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80705d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x705d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_LSB (at 0x7060)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG4_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG4_START_ADDR_MSB (at 0x7061)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_LSB (at 0x7064)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG5_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG5_START_ADDR_MSB (at 0x7065)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_LSB (at 0x7068)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG6_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG6_START_ADDR_MSB (at 0x7069)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_LSB (at 0x706c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG7_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG7_START_ADDR_MSB (at 0x706d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80706d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x706d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_LSB (at 0x7070)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG8_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG8_START_ADDR_MSB (at 0x7071)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_LSB (at 0x7074)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG9_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG9_START_ADDR_MSB (at 0x7075)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_LSB (at 0x7078)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG10_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG10_START_ADDR_MSB (at 0x7079)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_LSB (at 0x707c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG11_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG11_START_ADDR_MSB (at 0x707d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80707d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x707d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_LSB (at 0x7080)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG12_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG12_START_ADDR_MSB (at 0x7081)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070810
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70810
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_LSB (at 0x7084)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070840
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70840
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG13_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG13_START_ADDR_MSB (at 0x7085)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070850
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70850
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_LSB (at 0x7088)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG14_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG14_START_ADDR_MSB (at 0x7089)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070890
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70890
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_LSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_LSB (at 0x708c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_LSB                             = "
    tree.end
    tree "PBS_CORE_TRIG15_START_ADDR_MSB"
      sgroup "PBS_CORE_TRIG15_START_ADDR_MSB (at 0x708d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x80708d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x708d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEQ_ADDR_MSB                             = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS1"
      sgroup "PBS_CORE_SEQ_STATUS1 (at 0x7090)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEQ_IN_SERVICE                           = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_NORMAL                          = "
    tree.end
    tree "PBS_CORE_SEQ_STATUS2"
      sgroup "PBS_CORE_SEQ_STATUS2 (at 0x7091)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   LAST_SEQ_ABORTED                         = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   LAST_SEQ_ERROR                           = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS0 (at 0x7092)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070920
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70920
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_LSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_PC_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_PC_STATUS1 (at 0x7093)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070930
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70930
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_PC_MSB                               = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS0"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS0 (at 0x7094)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070940
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70940
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE0                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS1"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS1 (at 0x7095)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070950
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70950
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE1                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS2"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS2 (at 0x7096)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070960
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70960
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE2                             = "
    tree.end
    tree "PBS_CORE_SEQ_ERR_IR_STATUS3"
      sgroup "PBS_CORE_SEQ_ERR_IR_STATUS3 (at 0x7097)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070970
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70970
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERR_IR_BYTE3                             = "
    tree.end
    tree "PBS_CORE_SEC_ACCESS"
      sgroup "PBS_CORE_SEC_ACCESS (at 0x70d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL1"
      sgroup "PBS_CORE_PERPH_RESET_CTL1 (at 0x70d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL2"
      sgroup "PBS_CORE_PERPH_RESET_CTL2 (at 0x70d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL3"
      sgroup "PBS_CORE_PERPH_RESET_CTL3 (at 0x70da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PBS_CORE_PERPH_RESET_CTL4"
      sgroup "PBS_CORE_PERPH_RESET_CTL4 (at 0x70db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_CFG"
      sgroup "PBS_CORE_SEQ_DEBUG_CFG (at 0x70e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DEBUG_EN                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_SEQ_DEBUG_NEXT"
      sgroup "PBS_CORE_SEQ_DEBUG_NEXT (at 0x70e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   NEXT_CMD                                 = " "0, 1"
    tree.end
    tree "PBS_CORE_OTP_CFG1"
      sgroup "PBS_CORE_OTP_CFG1 (at 0x70e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   VPP_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PPROG                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PTM                                      = " "0, 1, 2, 3"
    tree.end
    tree "PBS_CORE_OTP_CFG2"
      sgroup "PBS_CORE_OTP_CFG2 (at 0x70e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MARGIN_RD_WS                             = "
    tree.end
    tree "PBS_CORE_TEST1"
      sgroup "PBS_CORE_TEST1 (at 0x70e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        set &access:&cmd_addr %l 0x8070e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x7000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x70e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
  tree.end
tree.end
tree "PON"
  tree "PON"
    tree "PON_REVISION1"
      sgroup "PON_REVISION1 (at 0x800)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "PON_REVISION2"
      sgroup "PON_REVISION2 (at 0x801)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "PON_REVISION3"
      sgroup "PON_REVISION3 (at 0x802)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "PON_REVISION4"
      sgroup "PON_REVISION4 (at 0x803)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "PON_PERPH_TYPE"
      sgroup "PON_PERPH_TYPE (at 0x804)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "PON_PERPH_SUBTYPE"
      sgroup "PON_PERPH_SUBTYPE (at 0x805)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "PON_PON_PBL_STATUS"
      sgroup "PON_PON_PBL_STATUS (at 0x807)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008070
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8070
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DVDD_RB_OCCURRED                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   XVDD_RB_OCCURRED                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   REG_WRITE_ERROR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   REG_RESET_ERROR                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   REG_SYNC_ERROR                           = " "0, 1"
    tree.end
    tree "PON_PON_REASON1"
      sgroup "PON_PON_REASON1 (at 0x808)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HARD_RESET                               = " "0, 1"
    tree.end
    tree "PON_WARM_RESET_REASON1"
      sgroup "PON_WARM_RESET_REASON1 (at 0x80a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0, 1"
    tree.end
    tree "PON_WARM_RESET_REASON2"
      sgroup "PON_WARM_RESET_REASON2 (at 0x80b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0, 1"
    tree.end
    tree "PON_POFF_REASON1"
      sgroup "PON_POFF_REASON1 (at 0x80c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0, 1"
    tree.end
    tree "PON_POFF_REASON2"
      sgroup "PON_POFF_REASON2 (at 0x80d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STAGE3                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OTST3                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   UVLO                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0, 1"
    tree.end
    tree "PON_SOFT_RESET_REASON1"
      sgroup "PON_SOFT_RESET_REASON1 (at 0x80e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   RESIN_N                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   KPDPWR_AND_RESIN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   GP2                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GP1                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PMIC_WD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_HOLD                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT                                     = " "0, 1"
    tree.end
    tree "PON_SOFT_RESET_REASON2"
      sgroup "PON_SOFT_RESET_REASON2 (at 0x80f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80080f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x80f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TFT                                      = " "0, 1"
    tree.end
    tree "PON_INT_RT_STS"
      sgroup "PON_INT_RT_STS (at 0x810)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_SET_TYPE"
      sgroup "PON_INT_SET_TYPE (at 0x811)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_POLARITY_HIGH"
      sgroup "PON_INT_POLARITY_HIGH (at 0x812)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_POLARITY_LOW"
      sgroup "PON_INT_POLARITY_LOW (at 0x813)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_LATCHED_CLR"
      sgroup "PON_INT_LATCHED_CLR (at 0x814)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_SET"
      sgroup "PON_INT_EN_SET (at 0x815)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_EN_CLR"
      sgroup "PON_INT_EN_CLR (at 0x816)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_LATCHED_STS"
      sgroup "PON_INT_LATCHED_STS (at 0x818)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_PENDING_STS"
      sgroup "PON_INT_PENDING_STS (at 0x819)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_INT_MID_SEL"
      sgroup "PON_INT_MID_SEL (at 0x81a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "PON_INT_PRIORITY"
      sgroup "PON_INT_PRIORITY (at 0x81b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80081b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x81b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "PON_KPDPWR_N_RESET_S1_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S1_TIMER (at 0x840)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_TIMER"
      sgroup "PON_KPDPWR_N_RESET_S2_TIMER (at 0x841)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_KPDPWR_N_RESET_S2_CTL"
      sgroup "PON_KPDPWR_N_RESET_S2_CTL (at 0x842)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_N_RESET_S1_TIMER"
      sgroup "PON_RESIN_N_RESET_S1_TIMER (at 0x844)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_N_RESET_S2_TIMER"
      sgroup "PON_RESIN_N_RESET_S2_TIMER (at 0x845)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_RESIN_N_RESET_S2_CTL"
      sgroup "PON_RESIN_N_RESET_S2_CTL (at 0x846)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S1_TIMER (at 0x848)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_TIMER (at 0x849)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008490
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8490
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_RESIN_AND_KPDPWR_RESET_S2_CTL"
      sgroup "PON_RESIN_AND_KPDPWR_RESET_S2_CTL (at 0x84a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP2_RESET_S1_TIMER"
      sgroup "PON_GP2_RESET_S1_TIMER (at 0x84c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP2_RESET_S2_TIMER"
      sgroup "PON_GP2_RESET_S2_TIMER (at 0x84d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_GP2_RESET_S2_CTL"
      sgroup "PON_GP2_RESET_S2_CTL (at 0x84e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80084e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x84e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_GP1_RESET_S1_TIMER"
      sgroup "PON_GP1_RESET_S1_TIMER (at 0x850)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_GP1_RESET_S2_TIMER"
      sgroup "PON_GP1_RESET_S2_TIMER (at 0x851)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S2_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_GP1_RESET_S2_CTL"
      sgroup "PON_GP1_RESET_S2_CTL (at 0x852)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_S1_TIMER"
      sgroup "PON_PMIC_WD_RESET_S1_TIMER (at 0x854)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S1_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_TIMER"
      sgroup "PON_PMIC_WD_RESET_S2_TIMER (at 0x855)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   S2_TIMER                                 = "
    tree.end
    tree "PON_PMIC_WD_RESET_S2_CTL"
      sgroup "PON_PMIC_WD_RESET_S2_CTL (at 0x856)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PMIC_WD_RESET_PET"
      sgroup "PON_PMIC_WD_RESET_PET (at 0x857)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008570
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8570
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   WATCHDOG_PET                             = " "0, 1"
    tree.end
    tree "PON_PS_HOLD_RESET_CTL"
      sgroup "PON_PS_HOLD_RESET_CTL (at 0x85a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80085a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x85a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_S2_CTL"
      sgroup "PON_SW_RESET_S2_CTL (at 0x862)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SW_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_SW_RESET_GO"
      sgroup "PON_SW_RESET_GO (at 0x863)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SW_RESET_GO                              = "
    tree.end
    tree "PON_OVERTEMP_RESET_CTL"
      sgroup "PON_OVERTEMP_RESET_CTL (at 0x866)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_TFT_RESET_CTL"
      sgroup "PON_TFT_RESET_CTL (at 0x86a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80086a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x86a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   S2_RESET_EN                              = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RESET_TYPE                               = "
    tree.end
    tree "PON_PULL_CTL"
      sgroup "PON_PULL_CTL (at 0x870)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON1_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_N_PU_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   KPDPWR_N_PU_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RESIN_N_PU_EN                            = " "0, 1"
    tree.end
    tree "PON_DEBOUNCE_CTL"
      sgroup "PON_DEBOUNCE_CTL (at 0x871)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DEBOUNCE                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_RESET_S3_SRC"
      sgroup "PON_RESET_S3_SRC (at 0x874)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   RESET_S3_SOURCE                          = " "0, 1, 2, 3"
    tree.end
    tree "PON_RESET_S3_TIMER"
      sgroup "PON_RESET_S3_TIMER (at 0x875)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   S3_TIMER                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_PON_TRIGGER_EN"
      sgroup "PON_PON_TRIGGER_EN (at 0x880)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008800
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8800
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   KPDPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CBLPWR_N                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PON1                                     = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   USB_CHG                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DC_CHG                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   RTC                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SMPL                                     = " "0, 1"
    tree.end
    tree "PON_OPTION_BITS"
      sgroup "PON_OPTION_BITS (at 0x882)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008820
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8820
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PMIC_WD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CLOCK_32K_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MBG_EN                                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   VPH_PWR_EN                               = " "0, 1"
    tree.end
    tree "PON_UVLO"
      sgroup "PON_UVLO (at 0x888)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008880
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8880
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   UVLO_DLY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "PON_AVDD_VPH"
      sgroup "PON_AVDD_VPH (at 0x88a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   AVDD_HPM_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   AVDD_REF_OVR                             = " "0, 1"
    tree.end
    tree "PON_PERPH_RB_SPARE"
      sgroup "PON_PERPH_RB_SPARE (at 0x88c)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_DVDD_RB_SPARE"
      sgroup "PON_DVDD_RB_SPARE (at 0x88d)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_XVDD_RB_SPARE"
      sgroup "PON_XVDD_RB_SPARE (at 0x88e)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_SOFT_RB_SPARE"
      sgroup "PON_SOFT_RB_SPARE (at 0x88f)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x80088f0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x88f0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SPARE                                    = "
    tree.end
    tree "PON_PON1_INTERFACE"
      sgroup "PON_PON1_INTERFACE (at 0x890)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008900
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8900
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PON_OUT                                  = " "0, 1"
    tree.end
    tree "PON_PBS_INTERFACE"
      sgroup "PON_PBS_INTERFACE (at 0x891)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008910
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8910
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ACK_NACK                                 = " "0, 1"
    tree.end
    tree "PON_SEC_ACCESS"
      sgroup "PON_SEC_ACCESS (at 0x8d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "PON_PERPH_RESET_CTL2"
      sgroup "PON_PERPH_RESET_CTL2 (at 0x8d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL3"
      sgroup "PON_PERPH_RESET_CTL3 (at 0x8da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "PON_PERPH_RESET_CTL4"
      sgroup "PON_PERPH_RESET_CTL4 (at 0x8db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "PON_INT_TEST1"
      sgroup "PON_INT_TEST1 (at 0x8e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "PON_INT_TEST_VAL"
      sgroup "PON_INT_TEST_VAL (at 0x8e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PMIC_WD_BARK                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   K_R_BARK                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   RESIN_BARK                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   KPDPWR_BARK                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CBLPWR_ON                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   RESIN_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   KPDPWR_ON                                = " "0, 1"
    tree.end
    tree "PON_TEST1"
      sgroup "PON_TEST1 (at 0x8e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UVLO_TEST_EN                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   FORCE_VPH_MAX                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FORCE_AVDD_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FAST_ON                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   BYPASS_TRIM_COPY                         = " "0, 1"
    tree.end
    tree "PON_TEST2"
      sgroup "PON_TEST2 (at 0x8e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ATEST2_AVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ATEST2_DVDD                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ATEST2_AVDD_OK                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ATEST1_VBG                               = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_EN                                 = "
    tree.end
    tree "PON_TEST3"
      sgroup "PON_TEST3 (at 0x8e4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   SEL_FSM                                  = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PON_WARM_REASON_CLEAR                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   USE_MSME_FOR_DVDD                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   STAY_ON                                  = " "0, 1"
    tree.end
    tree "PON_TEST4"
      sgroup "PON_TEST4 (at 0x8e5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   FSM_STATE                                = "
    tree.end
    tree "PON_TEST5"
      sgroup "PON_TEST5 (at 0x8e6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MASK_XVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   MASK_DVDD_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   MASK_SHUTDOWN1_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   MASK_SHUTDOWN2_RB                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MASK_WARM_RB                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MASK_GLOBAL_SOFT_RB                      = " "0, 1"
    tree.end
    tree "PON_VMAX_SEL"
      sgroup "PON_VMAX_SEL (at 0x8e7)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008e70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8e70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VMAX_SEL                                 = "
    tree.end
    tree "PON_TRIM_NUM"
      sgroup "PON_TRIM_NUM (at 0x8f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "PON_PON_TRIM"
      sgroup "PON_PON_TRIM (at 0x8f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PON_BG_TRIM                              = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   AVDD_REG_TRIM                            = "
    tree.end
    tree "PON_PON_CNTL_2_TRIM"
      sgroup "PON_PON_CNTL_2_TRIM (at 0x8f2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        set &access:&cmd_addr %l 0x8008f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x8f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x7 1 "  [ 7: 3]   UVLO_THRESH                              = "
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   UVLO_VOLT_HYST                           = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "REVID"
  tree "REVID"
    tree "REVID_REVISION1"
      sgroup "REVID_REVISION1 (at 0x100)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   RFU                                      = "
    tree.end
    tree "REVID_REVISION2"
      sgroup "REVID_REVISION2 (at 0x101)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VARIANT                                  = "
    tree.end
    tree "REVID_REVISION3"
      sgroup "REVID_REVISION3 (at 0x102)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   METAL                                    = "
    tree.end
    tree "REVID_REVISION4"
      sgroup "REVID_REVISION4 (at 0x103)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ALL_LAYER                                = "
    tree.end
    tree "REVID_PERPH_TYPE"
      sgroup "REVID_PERPH_TYPE (at 0x104)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "REVID_PERPH_SUBTYPE"
      sgroup "REVID_PERPH_SUBTYPE (at 0x105)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "REVID_STATUS1"
      sgroup "REVID_STATUS1 (at 0x108)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x6--0x7 "  [ 7: 6]   OP4                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   OP3                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   OP2                                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   OP1                                      = " "0, 1, 2, 3"
    tree.end
    tree "REVID_SEC_ACCESS"
      sgroup "REVID_SEC_ACCESS (at 0x1d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "REVID_TEST1"
      sgroup "REVID_TEST1 (at 0x1e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        set &access:&cmd_addr %l 0x8001e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FORCE_ON                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S1_CTRL"
  tree "S1_CTRL"
    tree "S1_CTRL_REVISION1"
      sgroup "S1_CTRL_REVISION1 (at 0x11400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION2"
      sgroup "S1_CTRL_REVISION2 (at 0x11401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_CTRL_REVISION3"
      sgroup "S1_CTRL_REVISION3 (at 0x11402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_CTRL_REVISION4"
      sgroup "S1_CTRL_REVISION4 (at 0x11403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_CTRL_PERPH_TYPE"
      sgroup "S1_CTRL_PERPH_TYPE (at 0x11404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_CTRL_PERPH_SUBTYPE"
      sgroup "S1_CTRL_PERPH_SUBTYPE (at 0x11405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_CTRL_STATUS"
      sgroup "S1_CTRL_STATUS (at 0x11408)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_RT_STS"
      sgroup "S1_CTRL_INT_RT_STS (at 0x11410)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_SET_TYPE"
      sgroup "S1_CTRL_INT_SET_TYPE (at 0x11411)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_POLARITY_HIGH"
      sgroup "S1_CTRL_INT_POLARITY_HIGH (at 0x11412)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_POLARITY_LOW"
      sgroup "S1_CTRL_INT_POLARITY_LOW (at 0x11413)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_LATCHED_CLR"
      sgroup "S1_CTRL_INT_LATCHED_CLR (at 0x11414)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_SET"
      sgroup "S1_CTRL_INT_EN_SET (at 0x11415)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_EN_CLR"
      sgroup "S1_CTRL_INT_EN_CLR (at 0x11416)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_LATCHED_STS"
      sgroup "S1_CTRL_INT_LATCHED_STS (at 0x11418)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_PENDING_STS"
      sgroup "S1_CTRL_INT_PENDING_STS (at 0x11419)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_MID_SEL"
      sgroup "S1_CTRL_INT_MID_SEL (at 0x1141a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_INT_PRIORITY"
      sgroup "S1_CTRL_INT_PRIORITY (at 0x1141b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80141b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x141b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL1"
      sgroup "S1_CTRL_VOLTAGE_CTL1 (at 0x11440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_VOLTAGE_CTL2"
      sgroup "S1_CTRL_VOLTAGE_CTL2 (at 0x11441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_PFM_CTL"
      sgroup "S1_CTRL_PFM_CTL (at 0x11444)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_MODE_CTL"
      sgroup "S1_CTRL_MODE_CTL (at 0x11445)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S1_CTRL_EN_CTL"
      sgroup "S1_CTRL_EN_CTL (at 0x11446)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S1_CTRL_PD_CTL"
      sgroup "S1_CTRL_PD_CTL (at 0x11448)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_COMP_CAP_CTL"
      sgroup "S1_CTRL_COMP_CAP_CTL (at 0x11451)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_GM_CTL"
      sgroup "S1_CTRL_GM_CTL (at 0x11452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S1_CTRL_RZ_CTL"
      sgroup "S1_CTRL_RZ_CTL (at 0x11453)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S1_CTRL_ISNS_CTRL"
      sgroup "S1_CTRL_ISNS_CTRL (at 0x11455)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0, 1"
    tree.end
    tree "S1_CTRL_SAW_CTL"
      sgroup "S1_CTRL_SAW_CTL (at 0x11456)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CURRENT_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   NSAW_CTRL                                = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_DMAX_CTL"
      sgroup "S1_CTRL_DMAX_CTL (at 0x11458)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0, 1"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_CTL"
      sgroup "S1_CTRL_PULSE_SKIP_CTL (at 0x11459)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0, 1"
    tree.end
    tree "S1_CTRL_PULSE_SKIP_THRES"
      sgroup "S1_CTRL_PULSE_SKIP_THRES (at 0x1145a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_AUTO_MODE_CTL"
      sgroup "S1_CTRL_AUTO_MODE_CTL (at 0x1145b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0, 1, 2, 3"
    tree.end
    tree "S1_CTRL_INZERO_COUNT_CTL"
      sgroup "S1_CTRL_INZERO_COUNT_CTL (at 0x1145c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PFM_COUNT_CTL"
      sgroup "S1_CTRL_PFM_COUNT_CTL (at 0x1145d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S1_CTRL_PS_VGA_CTL"
      sgroup "S1_CTRL_PS_VGA_CTL (at 0x1145e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80145e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x145e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S1_CTRL_STEPPER_SS_CTL"
      sgroup "S1_CTRL_STEPPER_SS_CTL (at 0x11460)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_STEPPER_VS_CTL"
      sgroup "S1_CTRL_STEPPER_VS_CTL (at 0x11461)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_FT_CTL"
      sgroup "S1_CTRL_FT_CTL (at 0x11462)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_CTRL_QMODE_SHADOW"
      sgroup "S1_CTRL_QMODE_SHADOW (at 0x11463)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S1_CTRL_UL_LL_CTRL"
      sgroup "S1_CTRL_UL_LL_CTRL (at 0x11468)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UL_INT_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LL_INT_EN                                = " "0, 1"
    tree.end
    tree "S1_CTRL_UL_VOLTAGE"
      sgroup "S1_CTRL_UL_VOLTAGE (at 0x11469)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_LL_VOLTAGE"
      sgroup "S1_CTRL_LL_VOLTAGE (at 0x1146b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80146b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x146b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S1_CTRL_UL_RANGE"
      sgroup "S1_CTRL_UL_RANGE (at 0x1146d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80146d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x146d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_LL_RANGE"
      sgroup "S1_CTRL_LL_RANGE (at 0x1146e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80146e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x146e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S1_CTRL_CTLR_MISC"
      sgroup "S1_CTRL_CTLR_MISC (at 0x1147a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x80147a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x147a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S1_CTRL_SEC_ACCESS"
      sgroup "S1_CTRL_SEC_ACCESS (at 0x114d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL1"
      sgroup "S1_CTRL_PERPH_RESET_CTL1 (at 0x114d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL2"
      sgroup "S1_CTRL_PERPH_RESET_CTL2 (at 0x114d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL3"
      sgroup "S1_CTRL_PERPH_RESET_CTL3 (at 0x114da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_CTRL_PERPH_RESET_CTL4"
      sgroup "S1_CTRL_PERPH_RESET_CTL4 (at 0x114db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_TEST1"
      sgroup "S1_CTRL_INT_TEST1 (at 0x114e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S1_CTRL_INT_TEST_VAL"
      sgroup "S1_CTRL_INT_TEST_VAL (at 0x114e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S1_CTRL_CTLR_TEST"
      sgroup "S1_CTRL_CTLR_TEST (at 0x114e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S1_CTRL_TRIM_NUM"
      sgroup "S1_CTRL_TRIM_NUM (at 0x114f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_CTRL_CTL_TRIM1"
      sgroup "S1_CTRL_CTL_TRIM1 (at 0x114f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S1_CTRL_CTL_TRIM2"
      sgroup "S1_CTRL_CTL_TRIM2 (at 0x114f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S1_CTRL_CTL_TRIM3"
      sgroup "S1_CTRL_CTL_TRIM3 (at 0x114f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S1_CTRL_CTL_TRIM4"
      sgroup "S1_CTRL_CTL_TRIM4 (at 0x114f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        set &access:&cmd_addr %l 0x8014f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x14f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0, 1"
    tree.end
  tree.end
tree.end
tree "S1_FREQ"
  tree "S1_FREQ"
    tree "S1_FREQ_REVISION1"
      sgroup "S1_FREQ_REVISION1 (at 0x11600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION2"
      sgroup "S1_FREQ_REVISION2 (at 0x11601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_FREQ_REVISION3"
      sgroup "S1_FREQ_REVISION3 (at 0x11602)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_FREQ_REVISION4"
      sgroup "S1_FREQ_REVISION4 (at 0x11603)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_FREQ_PERPH_TYPE"
      sgroup "S1_FREQ_PERPH_TYPE (at 0x11604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_FREQ_PERPH_SUBTYPE"
      sgroup "S1_FREQ_PERPH_SUBTYPE (at 0x11605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_FREQ_CLK_ENABLE"
      sgroup "S1_FREQ_CLK_ENABLE (at 0x11646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S1_FREQ_CLK_DIV"
      sgroup "S1_FREQ_CLK_DIV (at 0x11650)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S1_FREQ_CLK_PHASE"
      sgroup "S1_FREQ_CLK_PHASE (at 0x11651)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S1_FREQ_GANG_CTL1"
      sgroup "S1_FREQ_GANG_CTL1 (at 0x116c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S1_FREQ_GANG_CTL2"
      sgroup "S1_FREQ_GANG_CTL2 (at 0x116c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S1_FREQ_SEC_ACCESS"
      sgroup "S1_FREQ_SEC_ACCESS (at 0x116d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL2"
      sgroup "S1_FREQ_PERPH_RESET_CTL2 (at 0x116d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL3"
      sgroup "S1_FREQ_PERPH_RESET_CTL3 (at 0x116da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_FREQ_PERPH_RESET_CTL4"
      sgroup "S1_FREQ_PERPH_RESET_CTL4 (at 0x116db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_FREQ_TEST1"
      sgroup "S1_FREQ_TEST1 (at 0x116e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        set &access:&cmd_addr %l 0x8016e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x16e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S1_PS"
  tree "S1_PS"
    tree "S1_PS_REVISION1"
      sgroup "S1_PS_REVISION1 (at 0x11500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION2"
      sgroup "S1_PS_REVISION2 (at 0x11501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S1_PS_REVISION3"
      sgroup "S1_PS_REVISION3 (at 0x11502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S1_PS_REVISION4"
      sgroup "S1_PS_REVISION4 (at 0x11503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S1_PS_PERPH_TYPE"
      sgroup "S1_PS_PERPH_TYPE (at 0x11504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S1_PS_PERPH_SUBTYPE"
      sgroup "S1_PS_PERPH_SUBTYPE (at 0x11505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S1_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PWM_CURRENT_LIM_CTL (at 0x1154a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S1_PS_PFM_CURRENT_LIM_CTL (at 0x1154b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S1_PS_SOFT_START_CTL"
      sgroup "S1_PS_SOFT_START_CTL (at 0x1154c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x80154c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x154c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0, 1"
    tree.end
    tree "S1_PS_SWITCH_SIZE_CTL"
      sgroup "S1_PS_SWITCH_SIZE_CTL (at 0x11570)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   P_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   N_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   P_DRIVER_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_DRIVER_SIZE                            = " "0, 1"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL1"
      sgroup "S1_PS_DEAD_TIME_CTRL1 (at 0x11571)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0, 1"
    tree.end
    tree "S1_PS_DEAD_TIME_CTRL2"
      sgroup "S1_PS_DEAD_TIME_CTRL2 (at 0x11572)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S1_PS_BLNK_TIME_CTL"
      sgroup "S1_PS_BLNK_TIME_CTL (at 0x11573)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0, 1"
    tree.end
    tree "S1_PS_INZERO_CTL"
      sgroup "S1_PS_INZERO_CTL (at 0x11574)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0, 1"
    tree.end
    tree "S1_PS_DIG_FSM_CTL"
      sgroup "S1_PS_DIG_FSM_CTL (at 0x11575)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0, 1"
    tree.end
    tree "S1_PS_PWR_STG_MISC"
      sgroup "S1_PS_PWR_STG_MISC (at 0x11579)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0, 1"
    tree.end
    tree "S1_PS_SEC_ACCESS"
      sgroup "S1_PS_SEC_ACCESS (at 0x115d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S1_PS_PERPH_RESET_CTL1"
      sgroup "S1_PS_PERPH_RESET_CTL1 (at 0x115d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL2"
      sgroup "S1_PS_PERPH_RESET_CTL2 (at 0x115d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL3"
      sgroup "S1_PS_PERPH_RESET_CTL3 (at 0x115da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S1_PS_PERPH_RESET_CTL4"
      sgroup "S1_PS_PERPH_RESET_CTL4 (at 0x115db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S1_PS_FORCE_FET_TEST"
      sgroup "S1_PS_FORCE_FET_TEST (at 0x115e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0, 1, 2, 3"
    tree.end
    tree "S1_PS_PWR_STG_TEST"
      sgroup "S1_PS_PWR_STG_TEST (at 0x115e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S1_PS_TRIM_NUM"
      sgroup "S1_PS_TRIM_NUM (at 0x115f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S1_PS_PS_TRIM1"
      sgroup "S1_PS_PS_TRIM1 (at 0x115f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S1_PS_PS_TRIM2"
      sgroup "S1_PS_PS_TRIM2 (at 0x115f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        set &access:&cmd_addr %l 0x8015f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x15f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S2_CTRL"
  tree "S2_CTRL"
    tree "S2_CTRL_REVISION1"
      sgroup "S2_CTRL_REVISION1 (at 0x11700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION2"
      sgroup "S2_CTRL_REVISION2 (at 0x11701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_CTRL_REVISION3"
      sgroup "S2_CTRL_REVISION3 (at 0x11702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_CTRL_REVISION4"
      sgroup "S2_CTRL_REVISION4 (at 0x11703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_CTRL_PERPH_TYPE"
      sgroup "S2_CTRL_PERPH_TYPE (at 0x11704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_CTRL_PERPH_SUBTYPE"
      sgroup "S2_CTRL_PERPH_SUBTYPE (at 0x11705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_CTRL_STATUS_1"
      sgroup "S2_CTRL_STATUS_1 (at 0x11708)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S2_CTRL_STATUS_2"
      sgroup "S2_CTRL_STATUS_2 (at 0x11709)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S2_CTRL_STATUS_3"
      sgroup "S2_CTRL_STATUS_3 (at 0x1170a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80170a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x170a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S2_CTRL_STATUS_4"
      sgroup "S2_CTRL_STATUS_4 (at 0x1170b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80170b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x170b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_RT_STS"
      sgroup "S2_CTRL_INT_RT_STS (at 0x11710)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_SET_TYPE"
      sgroup "S2_CTRL_INT_SET_TYPE (at 0x11711)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_POLARITY_HIGH"
      sgroup "S2_CTRL_INT_POLARITY_HIGH (at 0x11712)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_POLARITY_LOW"
      sgroup "S2_CTRL_INT_POLARITY_LOW (at 0x11713)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_LATCHED_CLR"
      sgroup "S2_CTRL_INT_LATCHED_CLR (at 0x11714)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_SET"
      sgroup "S2_CTRL_INT_EN_SET (at 0x11715)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_EN_CLR"
      sgroup "S2_CTRL_INT_EN_CLR (at 0x11716)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_LATCHED_STS"
      sgroup "S2_CTRL_INT_LATCHED_STS (at 0x11718)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_PENDING_STS"
      sgroup "S2_CTRL_INT_PENDING_STS (at 0x11719)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_MID_SEL"
      sgroup "S2_CTRL_INT_MID_SEL (at 0x1171a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_INT_PRIORITY"
      sgroup "S2_CTRL_INT_PRIORITY (at 0x1171b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80171b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x171b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL1"
      sgroup "S2_CTRL_VOLTAGE_CTL1 (at 0x11740)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL2"
      sgroup "S2_CTRL_VOLTAGE_CTL2 (at 0x11741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_CTRL_VSET_VALID"
      sgroup "S2_CTRL_VSET_VALID (at 0x11742)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S2_CTRL_VOLTAGE_CTL3"
      sgroup "S2_CTRL_VOLTAGE_CTL3 (at 0x11744)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_MODE_CTL"
      sgroup "S2_CTRL_MODE_CTL (at 0x11745)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S2_CTRL_EN_CTL"
      sgroup "S2_CTRL_EN_CTL (at 0x11746)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S2_CTRL_PD_CTL"
      sgroup "S2_CTRL_PD_CTL (at 0x11748)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S2_CTRL_FREQ_CTL"
      sgroup "S2_CTRL_FREQ_CTL (at 0x11750)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_CTRL_MULTIPHASE_CTL"
      sgroup "S2_CTRL_MULTIPHASE_CTL (at 0x11751)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S2_CTRL_PHASE_CTL"
      sgroup "S2_CTRL_PHASE_CTL (at 0x11752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_PHASE_ID"
      sgroup "S2_CTRL_PHASE_ID (at 0x11753)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_PHASE_CNT"
      sgroup "S2_CTRL_PHASE_CNT (at 0x11754)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_SS_CTL"
      sgroup "S2_CTRL_SS_CTL (at 0x11760)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_VS_CTL"
      sgroup "S2_CTRL_VS_CTL (at 0x11761)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CORR_CFG"
      sgroup "S2_CTRL_CORR_CFG (at 0x11762)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S2_CTRL_RAMP_CFG"
      sgroup "S2_CTRL_RAMP_CFG (at 0x11763)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_COMPENS_CFG"
      sgroup "S2_CTRL_COMPENS_CFG (at 0x11764)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_VREG_OK"
      sgroup "S2_CTRL_CFG_VREG_OK (at 0x11765)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_VREG_FAULT"
      sgroup "S2_CTRL_CFG_VREG_FAULT (at 0x11766)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_PFM_COMP"
      sgroup "S2_CTRL_CFG_PFM_COMP (at 0x11767)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_UL_LL_CTL"
      sgroup "S2_CTRL_UL_LL_CTL (at 0x11768)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S2_CTRL_VSET_ULS"
      sgroup "S2_CTRL_VSET_ULS (at 0x11769)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S2_CTRL_ULS_VALID"
      sgroup "S2_CTRL_ULS_VALID (at 0x1176a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S2_CTRL_VSET_LLS"
      sgroup "S2_CTRL_VSET_LLS (at 0x1176b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S2_CTRL_LLS_VALID"
      sgroup "S2_CTRL_LLS_VALID (at 0x1176c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S2_CTRL_GPL_HI"
      sgroup "S2_CTRL_GPL_HI (at 0x1176d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S2_CTRL_GPL_LO"
      sgroup "S2_CTRL_GPL_LO (at 0x1176e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x80176e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x176e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S2_CTRL_CFG_ATEST1"
      sgroup "S2_CTRL_CFG_ATEST1 (at 0x117b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_ATEST2"
      sgroup "S2_CTRL_CFG_ATEST2 (at 0x117b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_ATEST3"
      sgroup "S2_CTRL_CFG_ATEST3 (at 0x117b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_ATEST4"
      sgroup "S2_CTRL_CFG_ATEST4 (at 0x117b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CFG_DTEST1"
      sgroup "S2_CTRL_CFG_DTEST1 (at 0x117b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_DTEST2"
      sgroup "S2_CTRL_CFG_DTEST2 (at 0x117b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_DTEST3"
      sgroup "S2_CTRL_CFG_DTEST3 (at 0x117b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_CTRL_CFG_DTEST4"
      sgroup "S2_CTRL_CFG_DTEST4 (at 0x117b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_GANG_CTL1"
      sgroup "S2_CTRL_GANG_CTL1 (at 0x117c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_CTRL_GANG_CTL2"
      sgroup "S2_CTRL_GANG_CTL2 (at 0x117c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_SEC_ACCESS"
      sgroup "S2_CTRL_SEC_ACCESS (at 0x117d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL1"
      sgroup "S2_CTRL_PERPH_RESET_CTL1 (at 0x117d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL2"
      sgroup "S2_CTRL_PERPH_RESET_CTL2 (at 0x117d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL3"
      sgroup "S2_CTRL_PERPH_RESET_CTL3 (at 0x117da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_CTRL_PERPH_RESET_CTL4"
      sgroup "S2_CTRL_PERPH_RESET_CTL4 (at 0x117db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_TEST1"
      sgroup "S2_CTRL_INT_TEST1 (at 0x117e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S2_CTRL_INT_TEST_VAL"
      sgroup "S2_CTRL_INT_TEST_VAL (at 0x117e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S2_CTRL_MODE_FSM_MASK"
      sgroup "S2_CTRL_MODE_FSM_MASK (at 0x117e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S2_CTRL_GATE_DRV_MUX"
      sgroup "S2_CTRL_GATE_DRV_MUX (at 0x117e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_CORR_DUTY_MUX"
      sgroup "S2_CTRL_CORR_DUTY_MUX (at 0x117e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S2_CTRL_EN_OPTIONS_DFT"
      sgroup "S2_CTRL_EN_OPTIONS_DFT (at 0x117e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S2_CTRL_CAL_CTL"
      sgroup "S2_CTRL_CAL_CTL (at 0x117e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S2_CTRL_IDAC_CAL_VAL"
      sgroup "S2_CTRL_IDAC_CAL_VAL (at 0x117e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_CORR_CAL_VAL"
      sgroup "S2_CTRL_CORR_CAL_VAL (at 0x117ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S2_CTRL_PWM_CAL_VAL"
      sgroup "S2_CTRL_PWM_CAL_VAL (at 0x117eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_PFM_CAL_VAL"
      sgroup "S2_CTRL_PFM_CAL_VAL (at 0x117ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S2_CTRL_MPHASE_IDAC"
      sgroup "S2_CTRL_MPHASE_IDAC (at 0x117ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S2_CTRL_TRIM_NUM"
      sgroup "S2_CTRL_TRIM_NUM (at 0x117f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_CAL_EN_TRIM"
      sgroup "S2_CTRL_CAL_EN_TRIM (at 0x117f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S2_CTRL_REFDAC_TRIM"
      sgroup "S2_CTRL_REFDAC_TRIM (at 0x117f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S2_CTRL_IDAC_TRIM"
      sgroup "S2_CTRL_IDAC_TRIM (at 0x117f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S2_CTRL_CORR_TRIM"
      sgroup "S2_CTRL_CORR_TRIM (at 0x117f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S2_CTRL_PWM_TRIM"
      sgroup "S2_CTRL_PWM_TRIM (at 0x117f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S2_CTRL_PFM_TRIM"
      sgroup "S2_CTRL_PFM_TRIM (at 0x117f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S2_CTRL_RAMP_TRIM"
      sgroup "S2_CTRL_RAMP_TRIM (at 0x117f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        set &access:&cmd_addr %l 0x8017f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x17f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S2_FREQ"
  tree "S2_FREQ"
    tree "S2_FREQ_REVISION1"
      sgroup "S2_FREQ_REVISION1 (at 0x11900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION2"
      sgroup "S2_FREQ_REVISION2 (at 0x11901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_FREQ_REVISION3"
      sgroup "S2_FREQ_REVISION3 (at 0x11902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_FREQ_REVISION4"
      sgroup "S2_FREQ_REVISION4 (at 0x11903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_FREQ_PERPH_TYPE"
      sgroup "S2_FREQ_PERPH_TYPE (at 0x11904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_FREQ_PERPH_SUBTYPE"
      sgroup "S2_FREQ_PERPH_SUBTYPE (at 0x11905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_FREQ_CLK_ENABLE"
      sgroup "S2_FREQ_CLK_ENABLE (at 0x11946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S2_FREQ_CLK_DIV"
      sgroup "S2_FREQ_CLK_DIV (at 0x11950)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S2_FREQ_CLK_PHASE"
      sgroup "S2_FREQ_CLK_PHASE (at 0x11951)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S2_FREQ_GANG_CTL1"
      sgroup "S2_FREQ_GANG_CTL1 (at 0x119c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_FREQ_GANG_CTL2"
      sgroup "S2_FREQ_GANG_CTL2 (at 0x119c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S2_FREQ_SEC_ACCESS"
      sgroup "S2_FREQ_SEC_ACCESS (at 0x119d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL2"
      sgroup "S2_FREQ_PERPH_RESET_CTL2 (at 0x119d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL3"
      sgroup "S2_FREQ_PERPH_RESET_CTL3 (at 0x119da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_FREQ_PERPH_RESET_CTL4"
      sgroup "S2_FREQ_PERPH_RESET_CTL4 (at 0x119db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_FREQ_TEST1"
      sgroup "S2_FREQ_TEST1 (at 0x119e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        set &access:&cmd_addr %l 0x8019e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x19e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S2_PS"
  tree "S2_PS"
    tree "S2_PS_REVISION1"
      sgroup "S2_PS_REVISION1 (at 0x11800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION2"
      sgroup "S2_PS_REVISION2 (at 0x11801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S2_PS_REVISION3"
      sgroup "S2_PS_REVISION3 (at 0x11802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S2_PS_REVISION4"
      sgroup "S2_PS_REVISION4 (at 0x11803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S2_PS_PERPH_TYPE"
      sgroup "S2_PS_PERPH_TYPE (at 0x11804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S2_PS_PERPH_SUBTYPE"
      sgroup "S2_PS_PERPH_SUBTYPE (at 0x11805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S2_PS_VOLTAGE_CTL1"
      sgroup "S2_PS_VOLTAGE_CTL1 (at 0x11840)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S2_PS_VOLTAGE_CTL2"
      sgroup "S2_PS_VOLTAGE_CTL2 (at 0x11841)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S2_PS_FREQ_CTL"
      sgroup "S2_PS_FREQ_CTL (at 0x11850)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S2_PS_MULTIPHASE_CTL"
      sgroup "S2_PS_MULTIPHASE_CTL (at 0x11851)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S2_PS_PHASE_CTL"
      sgroup "S2_PS_PHASE_CTL (at 0x11852)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_PHASE_ID"
      sgroup "S2_PS_PHASE_ID (at 0x11853)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_PHASE_CNT"
      sgroup "S2_PS_PHASE_CNT (at 0x11854)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_PWM_CL_CTL"
      sgroup "S2_PS_PWM_CL_CTL (at 0x11860)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_LPM_CL_CTL"
      sgroup "S2_PS_LPM_CL_CTL (at 0x11861)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_AUTO_CTL"
      sgroup "S2_PS_AUTO_CTL (at 0x11862)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S2_PS_FSM_MINON_CFG"
      sgroup "S2_PS_FSM_MINON_CFG (at 0x11870)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ICOMP_EN_CFG"
      sgroup "S2_PS_ICOMP_EN_CFG (at 0x11871)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ZX_CAL_CFG"
      sgroup "S2_PS_ZX_CAL_CFG (at 0x11872)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_NONOVLAP_CFG"
      sgroup "S2_PS_NONOVLAP_CFG (at 0x11873)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_MPHASE_PI_CFG1"
      sgroup "S2_PS_MPHASE_PI_CFG1 (at 0x11874)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG2"
      sgroup "S2_PS_MPHASE_PI_CFG2 (at 0x11875)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG3"
      sgroup "S2_PS_MPHASE_PI_CFG3 (at 0x11876)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG4"
      sgroup "S2_PS_MPHASE_PI_CFG4 (at 0x11877)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG5"
      sgroup "S2_PS_MPHASE_PI_CFG5 (at 0x11878)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S2_PS_MPHASE_PI_CFG6"
      sgroup "S2_PS_MPHASE_PI_CFG6 (at 0x11879)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S2_PS_CAL_FAULT"
      sgroup "S2_PS_CAL_FAULT (at 0x1187a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S2_PS_ADC_OUT"
      sgroup "S2_PS_ADC_OUT (at 0x1187b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S2_PS_MP_IAVG2"
      sgroup "S2_PS_MP_IAVG2 (at 0x1187c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S2_PS_MP_IAVG1"
      sgroup "S2_PS_MP_IAVG1 (at 0x1187d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S2_PS_MP_DAC_DATA"
      sgroup "S2_PS_MP_DAC_DATA (at 0x1187e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x80187e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x187e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S2_PS_GANG_CTL1"
      sgroup "S2_PS_GANG_CTL1 (at 0x118c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S2_PS_GANG_CTL2"
      sgroup "S2_PS_GANG_CTL2 (at 0x118c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S2_PS_SEC_ACCESS"
      sgroup "S2_PS_SEC_ACCESS (at 0x118d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S2_PS_PERPH_RESET_CTL1"
      sgroup "S2_PS_PERPH_RESET_CTL1 (at 0x118d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL2"
      sgroup "S2_PS_PERPH_RESET_CTL2 (at 0x118d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL3"
      sgroup "S2_PS_PERPH_RESET_CTL3 (at 0x118da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S2_PS_PERPH_RESET_CTL4"
      sgroup "S2_PS_PERPH_RESET_CTL4 (at 0x118db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S2_PS_ATEST12"
      sgroup "S2_PS_ATEST12 (at 0x118e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_ATEST34"
      sgroup "S2_PS_ATEST34 (at 0x118e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S2_PS_DTEST12"
      sgroup "S2_PS_DTEST12 (at 0x118e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S2_PS_DTEST43"
      sgroup "S2_PS_DTEST43 (at 0x118e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S2_PS_TRIM_NUM"
      sgroup "S2_PS_TRIM_NUM (at 0x118f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S2_PS_ZX_TRIM"
      sgroup "S2_PS_ZX_TRIM (at 0x118f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S2_PS_CL_TRIM"
      sgroup "S2_PS_CL_TRIM (at 0x118f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        set &access:&cmd_addr %l 0x8018f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x18f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S3_CTRL"
  tree "S3_CTRL"
    tree "S3_CTRL_REVISION1"
      sgroup "S3_CTRL_REVISION1 (at 0x11a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION2"
      sgroup "S3_CTRL_REVISION2 (at 0x11a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_CTRL_REVISION3"
      sgroup "S3_CTRL_REVISION3 (at 0x11a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_CTRL_REVISION4"
      sgroup "S3_CTRL_REVISION4 (at 0x11a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_CTRL_PERPH_TYPE"
      sgroup "S3_CTRL_PERPH_TYPE (at 0x11a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_CTRL_PERPH_SUBTYPE"
      sgroup "S3_CTRL_PERPH_SUBTYPE (at 0x11a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_CTRL_STATUS"
      sgroup "S3_CTRL_STATUS (at 0x11a08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   ILS                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   UL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   LL_VOLTAGE                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PS_TRUE                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_TRUE                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE                             = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_RT_STS"
      sgroup "S3_CTRL_INT_RT_STS (at 0x11a10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_SET_TYPE"
      sgroup "S3_CTRL_INT_SET_TYPE (at 0x11a11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_POLARITY_HIGH"
      sgroup "S3_CTRL_INT_POLARITY_HIGH (at 0x11a12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_POLARITY_LOW"
      sgroup "S3_CTRL_INT_POLARITY_LOW (at 0x11a13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_LATCHED_CLR"
      sgroup "S3_CTRL_INT_LATCHED_CLR (at 0x11a14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_EN_SET"
      sgroup "S3_CTRL_INT_EN_SET (at 0x11a15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_EN_CLR"
      sgroup "S3_CTRL_INT_EN_CLR (at 0x11a16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_LATCHED_STS"
      sgroup "S3_CTRL_INT_LATCHED_STS (at 0x11a18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_PENDING_STS"
      sgroup "S3_CTRL_INT_PENDING_STS (at 0x11a19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_MID_SEL"
      sgroup "S3_CTRL_INT_MID_SEL (at 0x11a1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_INT_PRIORITY"
      sgroup "S3_CTRL_INT_PRIORITY (at 0x11a1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL1"
      sgroup "S3_CTRL_VOLTAGE_CTL1 (at 0x11a40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_VOLTAGE_CTL2"
      sgroup "S3_CTRL_VOLTAGE_CTL2 (at 0x11a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_PFM_CTL"
      sgroup "S3_CTRL_PFM_CTL (at 0x11a44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOLT_CTL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   PFM_IBOOST                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   PFM_TYPE_I                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PFM_COMP_HYST                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PFM_COMP_PLS_FLTR                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_IPLIM_CTRL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_IPLIM_DLY                            = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_MODE_CTL"
      sgroup "S3_CTRL_MODE_CTL (at 0x11a45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PWM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FOLLOW_PMIC_AWAKE                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S3_CTRL_EN_CTL"
      sgroup "S3_CTRL_EN_CTL (at 0x11a46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_HWEN3                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_HWEN2                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_HWEN1                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_HWEN0                             = " "0, 1"
    tree.end
    tree "S3_CTRL_PD_CTL"
      sgroup "S3_CTRL_PD_CTL (at 0x11a48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_COMP_CAP_CTL"
      sgroup "S3_CTRL_COMP_CAP_CTL (at 0x11a51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   POLE2_CTRL                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CZ_CTRL                                  = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_GM_CTL"
      sgroup "S3_CTRL_GM_CTL (at 0x11a52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   GM_CTL                                   = "
    tree.end
    tree "S3_CTRL_RZ_CTL"
      sgroup "S3_CTRL_RZ_CTL (at 0x11a53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RZ_CTL                                   = "
    tree.end
    tree "S3_CTRL_ISNS_CTRL"
      sgroup "S3_CTRL_ISNS_CTRL (at 0x11a55)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a550
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a550
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SA_COMP_CAP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RES_IOS                             = " "0, 1"
    tree.end
    tree "S3_CTRL_SAW_CTL"
      sgroup "S3_CTRL_SAW_CTL (at 0x11a56)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a560
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a560
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CURRENT_CTRL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   NSAW_CTRL                                = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_DMAX_CTL"
      sgroup "S3_CTRL_DMAX_CTL (at 0x11a58)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a580
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a580
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DMAX_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   DMAX_TIME_SEL                            = " "0, 1"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_CTL"
      sgroup "S3_CTRL_PULSE_SKIP_CTL (at 0x11a59)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a590
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a590
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PS_TIME_HYST                             = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PSKIP_EXIT_SEL                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PS_METHOD                                = " "0, 1"
    tree.end
    tree "S3_CTRL_PULSE_SKIP_THRES"
      sgroup "S3_CTRL_PULSE_SKIP_THRES (at 0x11a5a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x3--0x6 1 "  [ 6: 3]   PS_VRST                                  = "
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PS_VSET                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_AUTO_MODE_CTL"
      sgroup "S3_CTRL_AUTO_MODE_CTL (at 0x11a5b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   PWM_PFM_SEL                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   PFM_PWM_SEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   MODE_SEL_DLY                             = " "0, 1, 2, 3"
    tree.end
    tree "S3_CTRL_INZERO_COUNT_CTL"
      sgroup "S3_CTRL_INZERO_COUNT_CTL (at 0x11a5c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PFM_COUNT_CTL"
      sgroup "S3_CTRL_PFM_COUNT_CTL (at 0x11a5d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   WINDOW_WIDTH                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   THRESHOLD                                = "
    tree.end
    tree "S3_CTRL_PS_VGA_CTL"
      sgroup "S3_CTRL_PS_VGA_CTL (at 0x11a5e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a5e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a5e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VGA_GAIN                                 = "
    tree.end
    tree "S3_CTRL_STEPPER_SS_CTL"
      sgroup "S3_CTRL_STEPPER_SS_CTL (at 0x11a60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_STEPPER_VS_CTL"
      sgroup "S3_CTRL_STEPPER_VS_CTL (at 0x11a61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   STEPPER_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   STEP                                     = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DELAY                                    = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_FT_CTL"
      sgroup "S3_CTRL_FT_CTL (at 0x11a62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   FT_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   GM_BOOST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   NL_DEAD_ZONE                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   NL_CUR_CTL                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_CTRL_QMODE_SHADOW"
      sgroup "S3_CTRL_QMODE_SHADOW (at 0x11a63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   FOLLOW_QM                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   QMODE_PS_METHOD                          = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   QMODE_PS_VRST                            = "
    tree.end
    tree "S3_CTRL_UL_LL_CTRL"
      sgroup "S3_CTRL_UL_LL_CTRL (at 0x11a68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   UL_INT_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LL_INT_EN                                = " "0, 1"
    tree.end
    tree "S3_CTRL_UL_VOLTAGE"
      sgroup "S3_CTRL_UL_VOLTAGE (at 0x11a69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_LL_VOLTAGE"
      sgroup "S3_CTRL_LL_VOLTAGE (at 0x11a6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   V_SET                                    = "
    tree.end
    tree "S3_CTRL_UL_RANGE"
      sgroup "S3_CTRL_UL_RANGE (at 0x11a6d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a6d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_LL_RANGE"
      sgroup "S3_CTRL_LL_RANGE (at 0x11a6e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a6e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   RANGE                                    = " "0, 1"
    tree.end
    tree "S3_CTRL_CTLR_MISC"
      sgroup "S3_CTRL_CTLR_MISC (at 0x11a7a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801a7a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPARE_0                                  = " "0, 1"
    tree.end
    tree "S3_CTRL_SEC_ACCESS"
      sgroup "S3_CTRL_SEC_ACCESS (at 0x11ad0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL1"
      sgroup "S3_CTRL_PERPH_RESET_CTL1 (at 0x11ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL2"
      sgroup "S3_CTRL_PERPH_RESET_CTL2 (at 0x11ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL3"
      sgroup "S3_CTRL_PERPH_RESET_CTL3 (at 0x11ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_CTRL_PERPH_RESET_CTL4"
      sgroup "S3_CTRL_PERPH_RESET_CTL4 (at 0x11adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_TEST1"
      sgroup "S3_CTRL_INT_TEST1 (at 0x11ae0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S3_CTRL_INT_TEST_VAL"
      sgroup "S3_CTRL_INT_TEST_VAL (at 0x11ae1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S3_CTRL_CTLR_TEST"
      sgroup "S3_CTRL_CTLR_TEST (at 0x11ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S3_CTRL_TRIM_NUM"
      sgroup "S3_CTRL_TRIM_NUM (at 0x11af0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_CTRL_CTL_TRIM1"
      sgroup "S3_CTRL_CTL_TRIM1 (at 0x11af1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   ERR_AMP_TRIM                             = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RES_DIV_TRIM                             = "
    tree.end
    tree "S3_CTRL_CTL_TRIM2"
      sgroup "S3_CTRL_CTL_TRIM2 (at 0x11af2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PFM_COMP_TRIM                            = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   VDIP_COMP_TRIM                           = "
    tree.end
    tree "S3_CTRL_CTL_TRIM3"
      sgroup "S3_CTRL_CTL_TRIM3 (at 0x11af3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   VGA_PS_TRIM                              = "
    tree.end
    tree "S3_CTRL_CTL_TRIM4"
      sgroup "S3_CTRL_CTL_TRIM4 (at 0x11af4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        set &access:&cmd_addr %l 0x801af40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1af40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PULL_DOWN_TRIM                           = " "0, 1"
    tree.end
  tree.end
tree.end
tree "S3_FREQ"
  tree "S3_FREQ"
    tree "S3_FREQ_REVISION1"
      sgroup "S3_FREQ_REVISION1 (at 0x11c00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION2"
      sgroup "S3_FREQ_REVISION2 (at 0x11c01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_FREQ_REVISION3"
      sgroup "S3_FREQ_REVISION3 (at 0x11c02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_FREQ_REVISION4"
      sgroup "S3_FREQ_REVISION4 (at 0x11c03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_FREQ_PERPH_TYPE"
      sgroup "S3_FREQ_PERPH_TYPE (at 0x11c04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_FREQ_PERPH_SUBTYPE"
      sgroup "S3_FREQ_PERPH_SUBTYPE (at 0x11c05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_FREQ_CLK_ENABLE"
      sgroup "S3_FREQ_CLK_ENABLE (at 0x11c46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S3_FREQ_CLK_DIV"
      sgroup "S3_FREQ_CLK_DIV (at 0x11c50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S3_FREQ_CLK_PHASE"
      sgroup "S3_FREQ_CLK_PHASE (at 0x11c51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801c510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1c510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S3_FREQ_GANG_CTL1"
      sgroup "S3_FREQ_GANG_CTL1 (at 0x11cc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S3_FREQ_GANG_CTL2"
      sgroup "S3_FREQ_GANG_CTL2 (at 0x11cc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S3_FREQ_SEC_ACCESS"
      sgroup "S3_FREQ_SEC_ACCESS (at 0x11cd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL2"
      sgroup "S3_FREQ_PERPH_RESET_CTL2 (at 0x11cd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL3"
      sgroup "S3_FREQ_PERPH_RESET_CTL3 (at 0x11cda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_FREQ_PERPH_RESET_CTL4"
      sgroup "S3_FREQ_PERPH_RESET_CTL4 (at 0x11cdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801cdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1cdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S3_FREQ_TEST1"
      sgroup "S3_FREQ_TEST1 (at 0x11ce2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        set &access:&cmd_addr %l 0x801ce20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1c00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ce20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S3_PS"
  tree "S3_PS"
    tree "S3_PS_REVISION1"
      sgroup "S3_PS_REVISION1 (at 0x11b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION2"
      sgroup "S3_PS_REVISION2 (at 0x11b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S3_PS_REVISION3"
      sgroup "S3_PS_REVISION3 (at 0x11b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S3_PS_REVISION4"
      sgroup "S3_PS_REVISION4 (at 0x11b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S3_PS_PERPH_TYPE"
      sgroup "S3_PS_PERPH_TYPE (at 0x11b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S3_PS_PERPH_SUBTYPE"
      sgroup "S3_PS_PERPH_SUBTYPE (at 0x11b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S3_PS_PWM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PWM_CURRENT_LIM_CTL (at 0x11b4a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   CURRENT_LIM_AUTOINT_SEL                  = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_PWM_SEL                      = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_PS_PFM_CURRENT_LIM_CTL"
      sgroup "S3_PS_PFM_CURRENT_LIM_CTL (at 0x11b4b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CURRENT_LIM_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CURRENT_LIM_SEL                          = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S3_PS_SOFT_START_CTL"
      sgroup "S3_PS_SOFT_START_CTL (at 0x11b4c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b4c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b4c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_EN                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SOFT_START_MODE_SEL                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   SOFT_START_ILIM_SEL                      = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SOFT_START_ILIM_STEP_DLY                 = " "0, 1"
    tree.end
    tree "S3_PS_SWITCH_SIZE_CTL"
      sgroup "S3_PS_SWITCH_SIZE_CTL (at 0x11b70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   P_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   N_SWITCH_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   P_DRIVER_SIZE                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   N_DRIVER_SIZE                            = " "0, 1"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL1"
      sgroup "S3_PS_DEAD_TIME_CTRL1 (at 0x11b71)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   DIG_DEADTIME_CTRL                        = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ANA_DEADTIME_CTRL                        = " "0, 1"
    tree.end
    tree "S3_PS_DEAD_TIME_CTRL2"
      sgroup "S3_PS_DEAD_TIME_CTRL2 (at 0x11b72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   EN_PSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   EN_NSW_DEAD_TIME                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NSW_DEAD_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PSW_DEAD_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S3_PS_BLNK_TIME_CTL"
      sgroup "S3_PS_BLNK_TIME_CTL (at 0x11b73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x1--0x2 "  [ 2: 1]   MIN_PON                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_BLNK_TIME                           = " "0, 1"
    tree.end
    tree "S3_PS_INZERO_CTL"
      sgroup "S3_PS_INZERO_CTL (at 0x11b74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INZERO_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   INZERO_OFFSET                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   INZERO_FORCE                             = " "0, 1"
    tree.end
    tree "S3_PS_DIG_FSM_CTL"
      sgroup "S3_PS_DIG_FSM_CTL (at 0x11b75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   FSM_SEL                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FSM_CTL4                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FSM_CTL3                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FSM_CTL2                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FSM_CTL1                                 = " "0, 1"
    tree.end
    tree "S3_PS_PWR_STG_MISC"
      sgroup "S3_PS_PWR_STG_MISC (at 0x11b79)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801b790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1b790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SPARE_7                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SPARE_6                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SPARE_5                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SPARE_4                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPARE_3                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SPARE_2                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SPARE_1                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ISNS_RATIO                               = " "0, 1"
    tree.end
    tree "S3_PS_SEC_ACCESS"
      sgroup "S3_PS_SEC_ACCESS (at 0x11bd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S3_PS_PERPH_RESET_CTL1"
      sgroup "S3_PS_PERPH_RESET_CTL1 (at 0x11bd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL2"
      sgroup "S3_PS_PERPH_RESET_CTL2 (at 0x11bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL3"
      sgroup "S3_PS_PERPH_RESET_CTL3 (at 0x11bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S3_PS_PERPH_RESET_CTL4"
      sgroup "S3_PS_PERPH_RESET_CTL4 (at 0x11bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S3_PS_FORCE_FET_TEST"
      sgroup "S3_PS_FORCE_FET_TEST (at 0x11be3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   KELVIN_SENSING_TEST_EN                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   FORCE_PFET_NFET                          = " "0, 1, 2, 3"
    tree.end
    tree "S3_PS_PWR_STG_TEST"
      sgroup "S3_PS_PWR_STG_TEST (at 0x11be4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801be40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1be40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x7 "  [ 7: 5]   ATEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x2--0x4 "  [ 4: 2]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   TRIM_CALIB_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   OPEN_LOOP_TEST_EN                        = " "0, 1"
    tree.end
    tree "S3_PS_TRIM_NUM"
      sgroup "S3_PS_TRIM_NUM (at 0x11bf0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "S3_PS_PS_TRIM1"
      sgroup "S3_PS_PS_TRIM1 (at 0x11bf1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x5 "  [ 5: 4]   IPLIM_TRIM                               = " "0, 1, 2, 3"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   INZERO_TRIM                              = "
    tree.end
    tree "S3_PS_PS_TRIM2"
      sgroup "S3_PS_PS_TRIM2 (at 0x11bf2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        set &access:&cmd_addr %l 0x801bf20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1bf20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SOFT_START_ILIM_STEP_DLY_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   SOFT_START_MODE_SEL_TRIM                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SOFT_START_IPLIM_STEP_EN_TRIM            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SOFT_START_IPLIM_TRIM                    = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   IPLIM_TRIM_OPT                           = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S4_CTRL"
  tree "S4_CTRL"
    tree "S4_CTRL_REVISION1"
      sgroup "S4_CTRL_REVISION1 (at 0x11d00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION2"
      sgroup "S4_CTRL_REVISION2 (at 0x11d01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_CTRL_REVISION3"
      sgroup "S4_CTRL_REVISION3 (at 0x11d02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_CTRL_REVISION4"
      sgroup "S4_CTRL_REVISION4 (at 0x11d03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_CTRL_PERPH_TYPE"
      sgroup "S4_CTRL_PERPH_TYPE (at 0x11d04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_CTRL_PERPH_SUBTYPE"
      sgroup "S4_CTRL_PERPH_SUBTYPE (at 0x11d05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_CTRL_STATUS_1"
      sgroup "S4_CTRL_STATUS_1 (at 0x11d08)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S4_CTRL_STATUS_2"
      sgroup "S4_CTRL_STATUS_2 (at 0x11d09)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S4_CTRL_STATUS_3"
      sgroup "S4_CTRL_STATUS_3 (at 0x11d0a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S4_CTRL_STATUS_4"
      sgroup "S4_CTRL_STATUS_4 (at 0x11d0b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_RT_STS"
      sgroup "S4_CTRL_INT_RT_STS (at 0x11d10)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_SET_TYPE"
      sgroup "S4_CTRL_INT_SET_TYPE (at 0x11d11)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_POLARITY_HIGH"
      sgroup "S4_CTRL_INT_POLARITY_HIGH (at 0x11d12)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_POLARITY_LOW"
      sgroup "S4_CTRL_INT_POLARITY_LOW (at 0x11d13)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_LATCHED_CLR"
      sgroup "S4_CTRL_INT_LATCHED_CLR (at 0x11d14)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_EN_SET"
      sgroup "S4_CTRL_INT_EN_SET (at 0x11d15)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_EN_CLR"
      sgroup "S4_CTRL_INT_EN_CLR (at 0x11d16)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_LATCHED_STS"
      sgroup "S4_CTRL_INT_LATCHED_STS (at 0x11d18)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_PENDING_STS"
      sgroup "S4_CTRL_INT_PENDING_STS (at 0x11d19)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_MID_SEL"
      sgroup "S4_CTRL_INT_MID_SEL (at 0x11d1a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_INT_PRIORITY"
      sgroup "S4_CTRL_INT_PRIORITY (at 0x11d1b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d1b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d1b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL1"
      sgroup "S4_CTRL_VOLTAGE_CTL1 (at 0x11d40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL2"
      sgroup "S4_CTRL_VOLTAGE_CTL2 (at 0x11d41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S4_CTRL_VSET_VALID"
      sgroup "S4_CTRL_VSET_VALID (at 0x11d42)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S4_CTRL_VOLTAGE_CTL3"
      sgroup "S4_CTRL_VOLTAGE_CTL3 (at 0x11d44)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_MODE_CTL"
      sgroup "S4_CTRL_MODE_CTL (at 0x11d45)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S4_CTRL_EN_CTL"
      sgroup "S4_CTRL_EN_CTL (at 0x11d46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S4_CTRL_PD_CTL"
      sgroup "S4_CTRL_PD_CTL (at 0x11d48)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S4_CTRL_FREQ_CTL"
      sgroup "S4_CTRL_FREQ_CTL (at 0x11d50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S4_CTRL_MULTIPHASE_CTL"
      sgroup "S4_CTRL_MULTIPHASE_CTL (at 0x11d51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S4_CTRL_PHASE_CTL"
      sgroup "S4_CTRL_PHASE_CTL (at 0x11d52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_PHASE_ID"
      sgroup "S4_CTRL_PHASE_ID (at 0x11d53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_PHASE_CNT"
      sgroup "S4_CTRL_PHASE_CNT (at 0x11d54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_SS_CTL"
      sgroup "S4_CTRL_SS_CTL (at 0x11d60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_VS_CTL"
      sgroup "S4_CTRL_VS_CTL (at 0x11d61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CORR_CFG"
      sgroup "S4_CTRL_CORR_CFG (at 0x11d62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S4_CTRL_RAMP_CFG"
      sgroup "S4_CTRL_RAMP_CFG (at 0x11d63)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_COMPENS_CFG"
      sgroup "S4_CTRL_COMPENS_CFG (at 0x11d64)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_VREG_OK"
      sgroup "S4_CTRL_CFG_VREG_OK (at 0x11d65)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_VREG_FAULT"
      sgroup "S4_CTRL_CFG_VREG_FAULT (at 0x11d66)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_PFM_COMP"
      sgroup "S4_CTRL_CFG_PFM_COMP (at 0x11d67)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_UL_LL_CTL"
      sgroup "S4_CTRL_UL_LL_CTL (at 0x11d68)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S4_CTRL_VSET_ULS"
      sgroup "S4_CTRL_VSET_ULS (at 0x11d69)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S4_CTRL_ULS_VALID"
      sgroup "S4_CTRL_ULS_VALID (at 0x11d6a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S4_CTRL_VSET_LLS"
      sgroup "S4_CTRL_VSET_LLS (at 0x11d6b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S4_CTRL_LLS_VALID"
      sgroup "S4_CTRL_LLS_VALID (at 0x11d6c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S4_CTRL_GPL_HI"
      sgroup "S4_CTRL_GPL_HI (at 0x11d6d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S4_CTRL_GPL_LO"
      sgroup "S4_CTRL_GPL_LO (at 0x11d6e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801d6e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1d6e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S4_CTRL_CFG_ATEST1"
      sgroup "S4_CTRL_CFG_ATEST1 (at 0x11db0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_ATEST2"
      sgroup "S4_CTRL_CFG_ATEST2 (at 0x11db1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_ATEST3"
      sgroup "S4_CTRL_CFG_ATEST3 (at 0x11db2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_ATEST4"
      sgroup "S4_CTRL_CFG_ATEST4 (at 0x11db3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CFG_DTEST1"
      sgroup "S4_CTRL_CFG_DTEST1 (at 0x11db4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_DTEST2"
      sgroup "S4_CTRL_CFG_DTEST2 (at 0x11db5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_DTEST3"
      sgroup "S4_CTRL_CFG_DTEST3 (at 0x11db6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_CTRL_CFG_DTEST4"
      sgroup "S4_CTRL_CFG_DTEST4 (at 0x11db7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801db70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1db70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_GANG_CTL1"
      sgroup "S4_CTRL_GANG_CTL1 (at 0x11dc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_CTRL_GANG_CTL2"
      sgroup "S4_CTRL_GANG_CTL2 (at 0x11dc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_SEC_ACCESS"
      sgroup "S4_CTRL_SEC_ACCESS (at 0x11dd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL1"
      sgroup "S4_CTRL_PERPH_RESET_CTL1 (at 0x11dd8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL2"
      sgroup "S4_CTRL_PERPH_RESET_CTL2 (at 0x11dd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL3"
      sgroup "S4_CTRL_PERPH_RESET_CTL3 (at 0x11dda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_CTRL_PERPH_RESET_CTL4"
      sgroup "S4_CTRL_PERPH_RESET_CTL4 (at 0x11ddb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801ddb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ddb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_TEST1"
      sgroup "S4_CTRL_INT_TEST1 (at 0x11de0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S4_CTRL_INT_TEST_VAL"
      sgroup "S4_CTRL_INT_TEST_VAL (at 0x11de1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S4_CTRL_MODE_FSM_MASK"
      sgroup "S4_CTRL_MODE_FSM_MASK (at 0x11de2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S4_CTRL_GATE_DRV_MUX"
      sgroup "S4_CTRL_GATE_DRV_MUX (at 0x11de3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_CORR_DUTY_MUX"
      sgroup "S4_CTRL_CORR_DUTY_MUX (at 0x11de4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S4_CTRL_EN_OPTIONS_DFT"
      sgroup "S4_CTRL_EN_OPTIONS_DFT (at 0x11de5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S4_CTRL_CAL_CTL"
      sgroup "S4_CTRL_CAL_CTL (at 0x11de8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S4_CTRL_IDAC_CAL_VAL"
      sgroup "S4_CTRL_IDAC_CAL_VAL (at 0x11de9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801de90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1de90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S4_CTRL_CORR_CAL_VAL"
      sgroup "S4_CTRL_CORR_CAL_VAL (at 0x11dea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S4_CTRL_PWM_CAL_VAL"
      sgroup "S4_CTRL_PWM_CAL_VAL (at 0x11deb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801deb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1deb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S4_CTRL_PFM_CAL_VAL"
      sgroup "S4_CTRL_PFM_CAL_VAL (at 0x11dec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801dec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1dec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S4_CTRL_MPHASE_IDAC"
      sgroup "S4_CTRL_MPHASE_IDAC (at 0x11ded)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801ded0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ded0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S4_CTRL_TRIM_NUM"
      sgroup "S4_CTRL_TRIM_NUM (at 0x11df0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S4_CTRL_CAL_EN_TRIM"
      sgroup "S4_CTRL_CAL_EN_TRIM (at 0x11df1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S4_CTRL_REFDAC_TRIM"
      sgroup "S4_CTRL_REFDAC_TRIM (at 0x11df2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S4_CTRL_IDAC_TRIM"
      sgroup "S4_CTRL_IDAC_TRIM (at 0x11df3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S4_CTRL_CORR_TRIM"
      sgroup "S4_CTRL_CORR_TRIM (at 0x11df4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S4_CTRL_PWM_TRIM"
      sgroup "S4_CTRL_PWM_TRIM (at 0x11df5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S4_CTRL_PFM_TRIM"
      sgroup "S4_CTRL_PFM_TRIM (at 0x11df6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S4_CTRL_RAMP_TRIM"
      sgroup "S4_CTRL_RAMP_TRIM (at 0x11df7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        set &access:&cmd_addr %l 0x801df70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1d00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1df70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S4_FREQ"
  tree "S4_FREQ"
    tree "S4_FREQ_REVISION1"
      sgroup "S4_FREQ_REVISION1 (at 0x11f00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION2"
      sgroup "S4_FREQ_REVISION2 (at 0x11f01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_FREQ_REVISION3"
      sgroup "S4_FREQ_REVISION3 (at 0x11f02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_FREQ_REVISION4"
      sgroup "S4_FREQ_REVISION4 (at 0x11f03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_FREQ_PERPH_TYPE"
      sgroup "S4_FREQ_PERPH_TYPE (at 0x11f04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_FREQ_PERPH_SUBTYPE"
      sgroup "S4_FREQ_PERPH_SUBTYPE (at 0x11f05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_FREQ_CLK_ENABLE"
      sgroup "S4_FREQ_CLK_ENABLE (at 0x11f46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S4_FREQ_CLK_DIV"
      sgroup "S4_FREQ_CLK_DIV (at 0x11f50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S4_FREQ_CLK_PHASE"
      sgroup "S4_FREQ_CLK_PHASE (at 0x11f51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801f510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1f510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S4_FREQ_GANG_CTL1"
      sgroup "S4_FREQ_GANG_CTL1 (at 0x11fc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_FREQ_GANG_CTL2"
      sgroup "S4_FREQ_GANG_CTL2 (at 0x11fc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S4_FREQ_SEC_ACCESS"
      sgroup "S4_FREQ_SEC_ACCESS (at 0x11fd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL2"
      sgroup "S4_FREQ_PERPH_RESET_CTL2 (at 0x11fd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL3"
      sgroup "S4_FREQ_PERPH_RESET_CTL3 (at 0x11fda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_FREQ_PERPH_RESET_CTL4"
      sgroup "S4_FREQ_PERPH_RESET_CTL4 (at 0x11fdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S4_FREQ_TEST1"
      sgroup "S4_FREQ_TEST1 (at 0x11fe2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        set &access:&cmd_addr %l 0x801fe20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1f00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1fe20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S4_PS"
  tree "S4_PS"
    tree "S4_PS_REVISION1"
      sgroup "S4_PS_REVISION1 (at 0x11e00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION2"
      sgroup "S4_PS_REVISION2 (at 0x11e01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S4_PS_REVISION3"
      sgroup "S4_PS_REVISION3 (at 0x11e02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S4_PS_REVISION4"
      sgroup "S4_PS_REVISION4 (at 0x11e03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S4_PS_PERPH_TYPE"
      sgroup "S4_PS_PERPH_TYPE (at 0x11e04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S4_PS_PERPH_SUBTYPE"
      sgroup "S4_PS_PERPH_SUBTYPE (at 0x11e05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S4_PS_VOLTAGE_CTL1"
      sgroup "S4_PS_VOLTAGE_CTL1 (at 0x11e40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S4_PS_VOLTAGE_CTL2"
      sgroup "S4_PS_VOLTAGE_CTL2 (at 0x11e41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S4_PS_FREQ_CTL"
      sgroup "S4_PS_FREQ_CTL (at 0x11e50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S4_PS_MULTIPHASE_CTL"
      sgroup "S4_PS_MULTIPHASE_CTL (at 0x11e51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S4_PS_PHASE_CTL"
      sgroup "S4_PS_PHASE_CTL (at 0x11e52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_PHASE_ID"
      sgroup "S4_PS_PHASE_ID (at 0x11e53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_PHASE_CNT"
      sgroup "S4_PS_PHASE_CNT (at 0x11e54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_PWM_CL_CTL"
      sgroup "S4_PS_PWM_CL_CTL (at 0x11e60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_PS_LPM_CL_CTL"
      sgroup "S4_PS_LPM_CL_CTL (at 0x11e61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_PS_AUTO_CTL"
      sgroup "S4_PS_AUTO_CTL (at 0x11e62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S4_PS_FSM_MINON_CFG"
      sgroup "S4_PS_FSM_MINON_CFG (at 0x11e70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_ICOMP_EN_CFG"
      sgroup "S4_PS_ICOMP_EN_CFG (at 0x11e71)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_ZX_CAL_CFG"
      sgroup "S4_PS_ZX_CAL_CFG (at 0x11e72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_NONOVLAP_CFG"
      sgroup "S4_PS_NONOVLAP_CFG (at 0x11e73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_MPHASE_PI_CFG1"
      sgroup "S4_PS_MPHASE_PI_CFG1 (at 0x11e74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG2"
      sgroup "S4_PS_MPHASE_PI_CFG2 (at 0x11e75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG3"
      sgroup "S4_PS_MPHASE_PI_CFG3 (at 0x11e76)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG4"
      sgroup "S4_PS_MPHASE_PI_CFG4 (at 0x11e77)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG5"
      sgroup "S4_PS_MPHASE_PI_CFG5 (at 0x11e78)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S4_PS_MPHASE_PI_CFG6"
      sgroup "S4_PS_MPHASE_PI_CFG6 (at 0x11e79)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S4_PS_CAL_FAULT"
      sgroup "S4_PS_CAL_FAULT (at 0x11e7a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S4_PS_ADC_OUT"
      sgroup "S4_PS_ADC_OUT (at 0x11e7b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S4_PS_MP_IAVG2"
      sgroup "S4_PS_MP_IAVG2 (at 0x11e7c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S4_PS_MP_IAVG1"
      sgroup "S4_PS_MP_IAVG1 (at 0x11e7d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S4_PS_MP_DAC_DATA"
      sgroup "S4_PS_MP_DAC_DATA (at 0x11e7e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801e7e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1e7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S4_PS_GANG_CTL1"
      sgroup "S4_PS_GANG_CTL1 (at 0x11ec0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ec00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ec00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S4_PS_GANG_CTL2"
      sgroup "S4_PS_GANG_CTL2 (at 0x11ec1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ec10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ec10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S4_PS_SEC_ACCESS"
      sgroup "S4_PS_SEC_ACCESS (at 0x11ed0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S4_PS_PERPH_RESET_CTL1"
      sgroup "S4_PS_PERPH_RESET_CTL1 (at 0x11ed8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL2"
      sgroup "S4_PS_PERPH_RESET_CTL2 (at 0x11ed9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL3"
      sgroup "S4_PS_PERPH_RESET_CTL3 (at 0x11eda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801eda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1eda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S4_PS_PERPH_RESET_CTL4"
      sgroup "S4_PS_PERPH_RESET_CTL4 (at 0x11edb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801edb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1edb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S4_PS_ATEST12"
      sgroup "S4_PS_ATEST12 (at 0x11ee2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_ATEST34"
      sgroup "S4_PS_ATEST34 (at 0x11ee3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S4_PS_DTEST12"
      sgroup "S4_PS_DTEST12 (at 0x11ee4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S4_PS_DTEST43"
      sgroup "S4_PS_DTEST43 (at 0x11ee5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S4_PS_TRIM_NUM"
      sgroup "S4_PS_TRIM_NUM (at 0x11ef0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S4_PS_ZX_TRIM"
      sgroup "S4_PS_ZX_TRIM (at 0x11ef1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S4_PS_CL_TRIM"
      sgroup "S4_PS_CL_TRIM (at 0x11ef2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        set &access:&cmd_addr %l 0x801ef20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x1e00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x1ef20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S5_CTRL"
  tree "S5_CTRL"
    tree "S5_CTRL_REVISION1"
      sgroup "S5_CTRL_REVISION1 (at 0x12000)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION2"
      sgroup "S5_CTRL_REVISION2 (at 0x12001)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_CTRL_REVISION3"
      sgroup "S5_CTRL_REVISION3 (at 0x12002)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_CTRL_REVISION4"
      sgroup "S5_CTRL_REVISION4 (at 0x12003)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_CTRL_PERPH_TYPE"
      sgroup "S5_CTRL_PERPH_TYPE (at 0x12004)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_CTRL_PERPH_SUBTYPE"
      sgroup "S5_CTRL_PERPH_SUBTYPE (at 0x12005)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_CTRL_STATUS_1"
      sgroup "S5_CTRL_STATUS_1 (at 0x12008)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S5_CTRL_STATUS_2"
      sgroup "S5_CTRL_STATUS_2 (at 0x12009)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S5_CTRL_STATUS_3"
      sgroup "S5_CTRL_STATUS_3 (at 0x1200a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80200a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x200a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S5_CTRL_STATUS_4"
      sgroup "S5_CTRL_STATUS_4 (at 0x1200b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80200b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x200b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_RT_STS"
      sgroup "S5_CTRL_INT_RT_STS (at 0x12010)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_SET_TYPE"
      sgroup "S5_CTRL_INT_SET_TYPE (at 0x12011)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_POLARITY_HIGH"
      sgroup "S5_CTRL_INT_POLARITY_HIGH (at 0x12012)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_POLARITY_LOW"
      sgroup "S5_CTRL_INT_POLARITY_LOW (at 0x12013)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_LATCHED_CLR"
      sgroup "S5_CTRL_INT_LATCHED_CLR (at 0x12014)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_EN_SET"
      sgroup "S5_CTRL_INT_EN_SET (at 0x12015)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_EN_CLR"
      sgroup "S5_CTRL_INT_EN_CLR (at 0x12016)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_LATCHED_STS"
      sgroup "S5_CTRL_INT_LATCHED_STS (at 0x12018)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_PENDING_STS"
      sgroup "S5_CTRL_INT_PENDING_STS (at 0x12019)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_MID_SEL"
      sgroup "S5_CTRL_INT_MID_SEL (at 0x1201a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80201a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x201a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_INT_PRIORITY"
      sgroup "S5_CTRL_INT_PRIORITY (at 0x1201b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80201b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x201b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL1"
      sgroup "S5_CTRL_VOLTAGE_CTL1 (at 0x12040)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL2"
      sgroup "S5_CTRL_VOLTAGE_CTL2 (at 0x12041)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S5_CTRL_VSET_VALID"
      sgroup "S5_CTRL_VSET_VALID (at 0x12042)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S5_CTRL_VOLTAGE_CTL3"
      sgroup "S5_CTRL_VOLTAGE_CTL3 (at 0x12044)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_MODE_CTL"
      sgroup "S5_CTRL_MODE_CTL (at 0x12045)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S5_CTRL_EN_CTL"
      sgroup "S5_CTRL_EN_CTL (at 0x12046)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S5_CTRL_PD_CTL"
      sgroup "S5_CTRL_PD_CTL (at 0x12048)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S5_CTRL_FREQ_CTL"
      sgroup "S5_CTRL_FREQ_CTL (at 0x12050)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S5_CTRL_MULTIPHASE_CTL"
      sgroup "S5_CTRL_MULTIPHASE_CTL (at 0x12051)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S5_CTRL_PHASE_CTL"
      sgroup "S5_CTRL_PHASE_CTL (at 0x12052)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_PHASE_ID"
      sgroup "S5_CTRL_PHASE_ID (at 0x12053)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_PHASE_CNT"
      sgroup "S5_CTRL_PHASE_CNT (at 0x12054)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_SS_CTL"
      sgroup "S5_CTRL_SS_CTL (at 0x12060)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_VS_CTL"
      sgroup "S5_CTRL_VS_CTL (at 0x12061)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CORR_CFG"
      sgroup "S5_CTRL_CORR_CFG (at 0x12062)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S5_CTRL_RAMP_CFG"
      sgroup "S5_CTRL_RAMP_CFG (at 0x12063)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_COMPENS_CFG"
      sgroup "S5_CTRL_COMPENS_CFG (at 0x12064)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_VREG_OK"
      sgroup "S5_CTRL_CFG_VREG_OK (at 0x12065)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_VREG_FAULT"
      sgroup "S5_CTRL_CFG_VREG_FAULT (at 0x12066)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_PFM_COMP"
      sgroup "S5_CTRL_CFG_PFM_COMP (at 0x12067)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_UL_LL_CTL"
      sgroup "S5_CTRL_UL_LL_CTL (at 0x12068)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S5_CTRL_VSET_ULS"
      sgroup "S5_CTRL_VSET_ULS (at 0x12069)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S5_CTRL_ULS_VALID"
      sgroup "S5_CTRL_ULS_VALID (at 0x1206a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S5_CTRL_VSET_LLS"
      sgroup "S5_CTRL_VSET_LLS (at 0x1206b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S5_CTRL_LLS_VALID"
      sgroup "S5_CTRL_LLS_VALID (at 0x1206c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S5_CTRL_GPL_HI"
      sgroup "S5_CTRL_GPL_HI (at 0x1206d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S5_CTRL_GPL_LO"
      sgroup "S5_CTRL_GPL_LO (at 0x1206e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x80206e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x206e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S5_CTRL_CFG_ATEST1"
      sgroup "S5_CTRL_CFG_ATEST1 (at 0x120b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_ATEST2"
      sgroup "S5_CTRL_CFG_ATEST2 (at 0x120b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_ATEST3"
      sgroup "S5_CTRL_CFG_ATEST3 (at 0x120b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_ATEST4"
      sgroup "S5_CTRL_CFG_ATEST4 (at 0x120b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CFG_DTEST1"
      sgroup "S5_CTRL_CFG_DTEST1 (at 0x120b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_DTEST2"
      sgroup "S5_CTRL_CFG_DTEST2 (at 0x120b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_DTEST3"
      sgroup "S5_CTRL_CFG_DTEST3 (at 0x120b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_CTRL_CFG_DTEST4"
      sgroup "S5_CTRL_CFG_DTEST4 (at 0x120b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_GANG_CTL1"
      sgroup "S5_CTRL_GANG_CTL1 (at 0x120c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_CTRL_GANG_CTL2"
      sgroup "S5_CTRL_GANG_CTL2 (at 0x120c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_SEC_ACCESS"
      sgroup "S5_CTRL_SEC_ACCESS (at 0x120d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL1"
      sgroup "S5_CTRL_PERPH_RESET_CTL1 (at 0x120d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL2"
      sgroup "S5_CTRL_PERPH_RESET_CTL2 (at 0x120d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL3"
      sgroup "S5_CTRL_PERPH_RESET_CTL3 (at 0x120da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_CTRL_PERPH_RESET_CTL4"
      sgroup "S5_CTRL_PERPH_RESET_CTL4 (at 0x120db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_TEST1"
      sgroup "S5_CTRL_INT_TEST1 (at 0x120e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S5_CTRL_INT_TEST_VAL"
      sgroup "S5_CTRL_INT_TEST_VAL (at 0x120e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S5_CTRL_MODE_FSM_MASK"
      sgroup "S5_CTRL_MODE_FSM_MASK (at 0x120e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S5_CTRL_GATE_DRV_MUX"
      sgroup "S5_CTRL_GATE_DRV_MUX (at 0x120e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_CORR_DUTY_MUX"
      sgroup "S5_CTRL_CORR_DUTY_MUX (at 0x120e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S5_CTRL_EN_OPTIONS_DFT"
      sgroup "S5_CTRL_EN_OPTIONS_DFT (at 0x120e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S5_CTRL_CAL_CTL"
      sgroup "S5_CTRL_CAL_CTL (at 0x120e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S5_CTRL_IDAC_CAL_VAL"
      sgroup "S5_CTRL_IDAC_CAL_VAL (at 0x120e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S5_CTRL_CORR_CAL_VAL"
      sgroup "S5_CTRL_CORR_CAL_VAL (at 0x120ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S5_CTRL_PWM_CAL_VAL"
      sgroup "S5_CTRL_PWM_CAL_VAL (at 0x120eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S5_CTRL_PFM_CAL_VAL"
      sgroup "S5_CTRL_PFM_CAL_VAL (at 0x120ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S5_CTRL_MPHASE_IDAC"
      sgroup "S5_CTRL_MPHASE_IDAC (at 0x120ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S5_CTRL_TRIM_NUM"
      sgroup "S5_CTRL_TRIM_NUM (at 0x120f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S5_CTRL_CAL_EN_TRIM"
      sgroup "S5_CTRL_CAL_EN_TRIM (at 0x120f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S5_CTRL_REFDAC_TRIM"
      sgroup "S5_CTRL_REFDAC_TRIM (at 0x120f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S5_CTRL_IDAC_TRIM"
      sgroup "S5_CTRL_IDAC_TRIM (at 0x120f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S5_CTRL_CORR_TRIM"
      sgroup "S5_CTRL_CORR_TRIM (at 0x120f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S5_CTRL_PWM_TRIM"
      sgroup "S5_CTRL_PWM_TRIM (at 0x120f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S5_CTRL_PFM_TRIM"
      sgroup "S5_CTRL_PFM_TRIM (at 0x120f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S5_CTRL_RAMP_TRIM"
      sgroup "S5_CTRL_RAMP_TRIM (at 0x120f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        set &access:&cmd_addr %l 0x8020f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2000
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x20f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S5_FREQ"
  tree "S5_FREQ"
    tree "S5_FREQ_REVISION1"
      sgroup "S5_FREQ_REVISION1 (at 0x12200)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION2"
      sgroup "S5_FREQ_REVISION2 (at 0x12201)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_FREQ_REVISION3"
      sgroup "S5_FREQ_REVISION3 (at 0x12202)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_FREQ_REVISION4"
      sgroup "S5_FREQ_REVISION4 (at 0x12203)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_FREQ_PERPH_TYPE"
      sgroup "S5_FREQ_PERPH_TYPE (at 0x12204)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_FREQ_PERPH_SUBTYPE"
      sgroup "S5_FREQ_PERPH_SUBTYPE (at 0x12205)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_FREQ_CLK_ENABLE"
      sgroup "S5_FREQ_CLK_ENABLE (at 0x12246)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S5_FREQ_CLK_DIV"
      sgroup "S5_FREQ_CLK_DIV (at 0x12250)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S5_FREQ_CLK_PHASE"
      sgroup "S5_FREQ_CLK_PHASE (at 0x12251)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S5_FREQ_GANG_CTL1"
      sgroup "S5_FREQ_GANG_CTL1 (at 0x122c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_FREQ_GANG_CTL2"
      sgroup "S5_FREQ_GANG_CTL2 (at 0x122c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S5_FREQ_SEC_ACCESS"
      sgroup "S5_FREQ_SEC_ACCESS (at 0x122d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL2"
      sgroup "S5_FREQ_PERPH_RESET_CTL2 (at 0x122d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL3"
      sgroup "S5_FREQ_PERPH_RESET_CTL3 (at 0x122da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_FREQ_PERPH_RESET_CTL4"
      sgroup "S5_FREQ_PERPH_RESET_CTL4 (at 0x122db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S5_FREQ_TEST1"
      sgroup "S5_FREQ_TEST1 (at 0x122e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        set &access:&cmd_addr %l 0x8022e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2200
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x22e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S5_PS"
  tree "S5_PS"
    tree "S5_PS_REVISION1"
      sgroup "S5_PS_REVISION1 (at 0x12100)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION2"
      sgroup "S5_PS_REVISION2 (at 0x12101)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S5_PS_REVISION3"
      sgroup "S5_PS_REVISION3 (at 0x12102)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S5_PS_REVISION4"
      sgroup "S5_PS_REVISION4 (at 0x12103)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S5_PS_PERPH_TYPE"
      sgroup "S5_PS_PERPH_TYPE (at 0x12104)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S5_PS_PERPH_SUBTYPE"
      sgroup "S5_PS_PERPH_SUBTYPE (at 0x12105)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S5_PS_VOLTAGE_CTL1"
      sgroup "S5_PS_VOLTAGE_CTL1 (at 0x12140)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S5_PS_VOLTAGE_CTL2"
      sgroup "S5_PS_VOLTAGE_CTL2 (at 0x12141)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S5_PS_FREQ_CTL"
      sgroup "S5_PS_FREQ_CTL (at 0x12150)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S5_PS_MULTIPHASE_CTL"
      sgroup "S5_PS_MULTIPHASE_CTL (at 0x12151)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S5_PS_PHASE_CTL"
      sgroup "S5_PS_PHASE_CTL (at 0x12152)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_PHASE_ID"
      sgroup "S5_PS_PHASE_ID (at 0x12153)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_PHASE_CNT"
      sgroup "S5_PS_PHASE_CNT (at 0x12154)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_PWM_CL_CTL"
      sgroup "S5_PS_PWM_CL_CTL (at 0x12160)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_PS_LPM_CL_CTL"
      sgroup "S5_PS_LPM_CL_CTL (at 0x12161)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_PS_AUTO_CTL"
      sgroup "S5_PS_AUTO_CTL (at 0x12162)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S5_PS_FSM_MINON_CFG"
      sgroup "S5_PS_FSM_MINON_CFG (at 0x12170)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_ICOMP_EN_CFG"
      sgroup "S5_PS_ICOMP_EN_CFG (at 0x12171)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_ZX_CAL_CFG"
      sgroup "S5_PS_ZX_CAL_CFG (at 0x12172)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_NONOVLAP_CFG"
      sgroup "S5_PS_NONOVLAP_CFG (at 0x12173)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_MPHASE_PI_CFG1"
      sgroup "S5_PS_MPHASE_PI_CFG1 (at 0x12174)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG2"
      sgroup "S5_PS_MPHASE_PI_CFG2 (at 0x12175)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG3"
      sgroup "S5_PS_MPHASE_PI_CFG3 (at 0x12176)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG4"
      sgroup "S5_PS_MPHASE_PI_CFG4 (at 0x12177)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG5"
      sgroup "S5_PS_MPHASE_PI_CFG5 (at 0x12178)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S5_PS_MPHASE_PI_CFG6"
      sgroup "S5_PS_MPHASE_PI_CFG6 (at 0x12179)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S5_PS_CAL_FAULT"
      sgroup "S5_PS_CAL_FAULT (at 0x1217a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S5_PS_ADC_OUT"
      sgroup "S5_PS_ADC_OUT (at 0x1217b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S5_PS_MP_IAVG2"
      sgroup "S5_PS_MP_IAVG2 (at 0x1217c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S5_PS_MP_IAVG1"
      sgroup "S5_PS_MP_IAVG1 (at 0x1217d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S5_PS_MP_DAC_DATA"
      sgroup "S5_PS_MP_DAC_DATA (at 0x1217e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x80217e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x217e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S5_PS_GANG_CTL1"
      sgroup "S5_PS_GANG_CTL1 (at 0x121c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S5_PS_GANG_CTL2"
      sgroup "S5_PS_GANG_CTL2 (at 0x121c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S5_PS_SEC_ACCESS"
      sgroup "S5_PS_SEC_ACCESS (at 0x121d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S5_PS_PERPH_RESET_CTL1"
      sgroup "S5_PS_PERPH_RESET_CTL1 (at 0x121d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL2"
      sgroup "S5_PS_PERPH_RESET_CTL2 (at 0x121d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL3"
      sgroup "S5_PS_PERPH_RESET_CTL3 (at 0x121da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S5_PS_PERPH_RESET_CTL4"
      sgroup "S5_PS_PERPH_RESET_CTL4 (at 0x121db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S5_PS_ATEST12"
      sgroup "S5_PS_ATEST12 (at 0x121e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_ATEST34"
      sgroup "S5_PS_ATEST34 (at 0x121e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S5_PS_DTEST12"
      sgroup "S5_PS_DTEST12 (at 0x121e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S5_PS_DTEST43"
      sgroup "S5_PS_DTEST43 (at 0x121e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S5_PS_TRIM_NUM"
      sgroup "S5_PS_TRIM_NUM (at 0x121f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S5_PS_ZX_TRIM"
      sgroup "S5_PS_ZX_TRIM (at 0x121f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S5_PS_CL_TRIM"
      sgroup "S5_PS_CL_TRIM (at 0x121f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        set &access:&cmd_addr %l 0x8021f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2100
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x21f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S6_CTRL"
  tree "S6_CTRL"
    tree "S6_CTRL_REVISION1"
      sgroup "S6_CTRL_REVISION1 (at 0x12300)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_CTRL_REVISION2"
      sgroup "S6_CTRL_REVISION2 (at 0x12301)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_CTRL_REVISION3"
      sgroup "S6_CTRL_REVISION3 (at 0x12302)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_CTRL_REVISION4"
      sgroup "S6_CTRL_REVISION4 (at 0x12303)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_CTRL_PERPH_TYPE"
      sgroup "S6_CTRL_PERPH_TYPE (at 0x12304)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_CTRL_PERPH_SUBTYPE"
      sgroup "S6_CTRL_PERPH_SUBTYPE (at 0x12305)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_CTRL_STATUS_1"
      sgroup "S6_CTRL_STATUS_1 (at 0x12308)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S6_CTRL_STATUS_2"
      sgroup "S6_CTRL_STATUS_2 (at 0x12309)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S6_CTRL_STATUS_3"
      sgroup "S6_CTRL_STATUS_3 (at 0x1230a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80230a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x230a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S6_CTRL_STATUS_4"
      sgroup "S6_CTRL_STATUS_4 (at 0x1230b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80230b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x230b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_RT_STS"
      sgroup "S6_CTRL_INT_RT_STS (at 0x12310)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_SET_TYPE"
      sgroup "S6_CTRL_INT_SET_TYPE (at 0x12311)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_POLARITY_HIGH"
      sgroup "S6_CTRL_INT_POLARITY_HIGH (at 0x12312)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_POLARITY_LOW"
      sgroup "S6_CTRL_INT_POLARITY_LOW (at 0x12313)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_LATCHED_CLR"
      sgroup "S6_CTRL_INT_LATCHED_CLR (at 0x12314)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_EN_SET"
      sgroup "S6_CTRL_INT_EN_SET (at 0x12315)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_EN_CLR"
      sgroup "S6_CTRL_INT_EN_CLR (at 0x12316)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_LATCHED_STS"
      sgroup "S6_CTRL_INT_LATCHED_STS (at 0x12318)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_PENDING_STS"
      sgroup "S6_CTRL_INT_PENDING_STS (at 0x12319)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_MID_SEL"
      sgroup "S6_CTRL_INT_MID_SEL (at 0x1231a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80231a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x231a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_INT_PRIORITY"
      sgroup "S6_CTRL_INT_PRIORITY (at 0x1231b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80231b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x231b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL1"
      sgroup "S6_CTRL_VOLTAGE_CTL1 (at 0x12340)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL2"
      sgroup "S6_CTRL_VOLTAGE_CTL2 (at 0x12341)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S6_CTRL_VSET_VALID"
      sgroup "S6_CTRL_VSET_VALID (at 0x12342)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S6_CTRL_VOLTAGE_CTL3"
      sgroup "S6_CTRL_VOLTAGE_CTL3 (at 0x12344)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_MODE_CTL"
      sgroup "S6_CTRL_MODE_CTL (at 0x12345)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S6_CTRL_EN_CTL"
      sgroup "S6_CTRL_EN_CTL (at 0x12346)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S6_CTRL_PD_CTL"
      sgroup "S6_CTRL_PD_CTL (at 0x12348)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S6_CTRL_FREQ_CTL"
      sgroup "S6_CTRL_FREQ_CTL (at 0x12350)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S6_CTRL_MULTIPHASE_CTL"
      sgroup "S6_CTRL_MULTIPHASE_CTL (at 0x12351)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S6_CTRL_PHASE_CTL"
      sgroup "S6_CTRL_PHASE_CTL (at 0x12352)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_PHASE_ID"
      sgroup "S6_CTRL_PHASE_ID (at 0x12353)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_PHASE_CNT"
      sgroup "S6_CTRL_PHASE_CNT (at 0x12354)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_SS_CTL"
      sgroup "S6_CTRL_SS_CTL (at 0x12360)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_VS_CTL"
      sgroup "S6_CTRL_VS_CTL (at 0x12361)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CORR_CFG"
      sgroup "S6_CTRL_CORR_CFG (at 0x12362)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S6_CTRL_RAMP_CFG"
      sgroup "S6_CTRL_RAMP_CFG (at 0x12363)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_COMPENS_CFG"
      sgroup "S6_CTRL_COMPENS_CFG (at 0x12364)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_VREG_OK"
      sgroup "S6_CTRL_CFG_VREG_OK (at 0x12365)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_VREG_FAULT"
      sgroup "S6_CTRL_CFG_VREG_FAULT (at 0x12366)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_PFM_COMP"
      sgroup "S6_CTRL_CFG_PFM_COMP (at 0x12367)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S6_CTRL_UL_LL_CTL"
      sgroup "S6_CTRL_UL_LL_CTL (at 0x12368)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S6_CTRL_VSET_ULS"
      sgroup "S6_CTRL_VSET_ULS (at 0x12369)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S6_CTRL_ULS_VALID"
      sgroup "S6_CTRL_ULS_VALID (at 0x1236a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80236a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x236a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S6_CTRL_VSET_LLS"
      sgroup "S6_CTRL_VSET_LLS (at 0x1236b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80236b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x236b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S6_CTRL_LLS_VALID"
      sgroup "S6_CTRL_LLS_VALID (at 0x1236c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80236c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x236c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S6_CTRL_GPL_HI"
      sgroup "S6_CTRL_GPL_HI (at 0x1236d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80236d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x236d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S6_CTRL_GPL_LO"
      sgroup "S6_CTRL_GPL_LO (at 0x1236e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x80236e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x236e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S6_CTRL_CFG_ATEST1"
      sgroup "S6_CTRL_CFG_ATEST1 (at 0x123b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_ATEST2"
      sgroup "S6_CTRL_CFG_ATEST2 (at 0x123b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_ATEST3"
      sgroup "S6_CTRL_CFG_ATEST3 (at 0x123b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_ATEST4"
      sgroup "S6_CTRL_CFG_ATEST4 (at 0x123b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CFG_DTEST1"
      sgroup "S6_CTRL_CFG_DTEST1 (at 0x123b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_DTEST2"
      sgroup "S6_CTRL_CFG_DTEST2 (at 0x123b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_DTEST3"
      sgroup "S6_CTRL_CFG_DTEST3 (at 0x123b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_CTRL_CFG_DTEST4"
      sgroup "S6_CTRL_CFG_DTEST4 (at 0x123b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_GANG_CTL1"
      sgroup "S6_CTRL_GANG_CTL1 (at 0x123c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_CTRL_GANG_CTL2"
      sgroup "S6_CTRL_GANG_CTL2 (at 0x123c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S6_CTRL_SEC_ACCESS"
      sgroup "S6_CTRL_SEC_ACCESS (at 0x123d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL1"
      sgroup "S6_CTRL_PERPH_RESET_CTL1 (at 0x123d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL2"
      sgroup "S6_CTRL_PERPH_RESET_CTL2 (at 0x123d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL3"
      sgroup "S6_CTRL_PERPH_RESET_CTL3 (at 0x123da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_CTRL_PERPH_RESET_CTL4"
      sgroup "S6_CTRL_PERPH_RESET_CTL4 (at 0x123db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_TEST1"
      sgroup "S6_CTRL_INT_TEST1 (at 0x123e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S6_CTRL_INT_TEST_VAL"
      sgroup "S6_CTRL_INT_TEST_VAL (at 0x123e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S6_CTRL_MODE_FSM_MASK"
      sgroup "S6_CTRL_MODE_FSM_MASK (at 0x123e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S6_CTRL_GATE_DRV_MUX"
      sgroup "S6_CTRL_GATE_DRV_MUX (at 0x123e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_CORR_DUTY_MUX"
      sgroup "S6_CTRL_CORR_DUTY_MUX (at 0x123e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S6_CTRL_EN_OPTIONS_DFT"
      sgroup "S6_CTRL_EN_OPTIONS_DFT (at 0x123e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S6_CTRL_CAL_CTL"
      sgroup "S6_CTRL_CAL_CTL (at 0x123e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S6_CTRL_IDAC_CAL_VAL"
      sgroup "S6_CTRL_IDAC_CAL_VAL (at 0x123e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S6_CTRL_CORR_CAL_VAL"
      sgroup "S6_CTRL_CORR_CAL_VAL (at 0x123ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S6_CTRL_PWM_CAL_VAL"
      sgroup "S6_CTRL_PWM_CAL_VAL (at 0x123eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S6_CTRL_PFM_CAL_VAL"
      sgroup "S6_CTRL_PFM_CAL_VAL (at 0x123ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S6_CTRL_MPHASE_IDAC"
      sgroup "S6_CTRL_MPHASE_IDAC (at 0x123ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S6_CTRL_TRIM_NUM"
      sgroup "S6_CTRL_TRIM_NUM (at 0x123f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S6_CTRL_CAL_EN_TRIM"
      sgroup "S6_CTRL_CAL_EN_TRIM (at 0x123f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S6_CTRL_REFDAC_TRIM"
      sgroup "S6_CTRL_REFDAC_TRIM (at 0x123f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S6_CTRL_IDAC_TRIM"
      sgroup "S6_CTRL_IDAC_TRIM (at 0x123f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S6_CTRL_CORR_TRIM"
      sgroup "S6_CTRL_CORR_TRIM (at 0x123f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S6_CTRL_PWM_TRIM"
      sgroup "S6_CTRL_PWM_TRIM (at 0x123f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S6_CTRL_PFM_TRIM"
      sgroup "S6_CTRL_PFM_TRIM (at 0x123f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S6_CTRL_RAMP_TRIM"
      sgroup "S6_CTRL_RAMP_TRIM (at 0x123f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        set &access:&cmd_addr %l 0x8023f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2300
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x23f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S6_FREQ"
  tree "S6_FREQ"
    tree "S6_FREQ_REVISION1"
      sgroup "S6_FREQ_REVISION1 (at 0x12500)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_FREQ_REVISION2"
      sgroup "S6_FREQ_REVISION2 (at 0x12501)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_FREQ_REVISION3"
      sgroup "S6_FREQ_REVISION3 (at 0x12502)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_FREQ_REVISION4"
      sgroup "S6_FREQ_REVISION4 (at 0x12503)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_FREQ_PERPH_TYPE"
      sgroup "S6_FREQ_PERPH_TYPE (at 0x12504)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_FREQ_PERPH_SUBTYPE"
      sgroup "S6_FREQ_PERPH_SUBTYPE (at 0x12505)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_FREQ_CLK_ENABLE"
      sgroup "S6_FREQ_CLK_ENABLE (at 0x12546)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S6_FREQ_CLK_DIV"
      sgroup "S6_FREQ_CLK_DIV (at 0x12550)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S6_FREQ_CLK_PHASE"
      sgroup "S6_FREQ_CLK_PHASE (at 0x12551)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S6_FREQ_GANG_CTL1"
      sgroup "S6_FREQ_GANG_CTL1 (at 0x125c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_FREQ_GANG_CTL2"
      sgroup "S6_FREQ_GANG_CTL2 (at 0x125c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S6_FREQ_SEC_ACCESS"
      sgroup "S6_FREQ_SEC_ACCESS (at 0x125d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL2"
      sgroup "S6_FREQ_PERPH_RESET_CTL2 (at 0x125d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL3"
      sgroup "S6_FREQ_PERPH_RESET_CTL3 (at 0x125da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_FREQ_PERPH_RESET_CTL4"
      sgroup "S6_FREQ_PERPH_RESET_CTL4 (at 0x125db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S6_FREQ_TEST1"
      sgroup "S6_FREQ_TEST1 (at 0x125e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        set &access:&cmd_addr %l 0x8025e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2500
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x25e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S6_PS"
  tree "S6_PS"
    tree "S6_PS_REVISION1"
      sgroup "S6_PS_REVISION1 (at 0x12400)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S6_PS_REVISION2"
      sgroup "S6_PS_REVISION2 (at 0x12401)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S6_PS_REVISION3"
      sgroup "S6_PS_REVISION3 (at 0x12402)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S6_PS_REVISION4"
      sgroup "S6_PS_REVISION4 (at 0x12403)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S6_PS_PERPH_TYPE"
      sgroup "S6_PS_PERPH_TYPE (at 0x12404)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S6_PS_PERPH_SUBTYPE"
      sgroup "S6_PS_PERPH_SUBTYPE (at 0x12405)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S6_PS_VOLTAGE_CTL1"
      sgroup "S6_PS_VOLTAGE_CTL1 (at 0x12440)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S6_PS_VOLTAGE_CTL2"
      sgroup "S6_PS_VOLTAGE_CTL2 (at 0x12441)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S6_PS_FREQ_CTL"
      sgroup "S6_PS_FREQ_CTL (at 0x12450)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S6_PS_MULTIPHASE_CTL"
      sgroup "S6_PS_MULTIPHASE_CTL (at 0x12451)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S6_PS_PHASE_CTL"
      sgroup "S6_PS_PHASE_CTL (at 0x12452)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_PHASE_ID"
      sgroup "S6_PS_PHASE_ID (at 0x12453)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_PHASE_CNT"
      sgroup "S6_PS_PHASE_CNT (at 0x12454)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_PWM_CL_CTL"
      sgroup "S6_PS_PWM_CL_CTL (at 0x12460)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_PS_LPM_CL_CTL"
      sgroup "S6_PS_LPM_CL_CTL (at 0x12461)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_PS_AUTO_CTL"
      sgroup "S6_PS_AUTO_CTL (at 0x12462)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S6_PS_FSM_MINON_CFG"
      sgroup "S6_PS_FSM_MINON_CFG (at 0x12470)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_ICOMP_EN_CFG"
      sgroup "S6_PS_ICOMP_EN_CFG (at 0x12471)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_ZX_CAL_CFG"
      sgroup "S6_PS_ZX_CAL_CFG (at 0x12472)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_NONOVLAP_CFG"
      sgroup "S6_PS_NONOVLAP_CFG (at 0x12473)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_MPHASE_PI_CFG1"
      sgroup "S6_PS_MPHASE_PI_CFG1 (at 0x12474)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG2"
      sgroup "S6_PS_MPHASE_PI_CFG2 (at 0x12475)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG3"
      sgroup "S6_PS_MPHASE_PI_CFG3 (at 0x12476)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG4"
      sgroup "S6_PS_MPHASE_PI_CFG4 (at 0x12477)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG5"
      sgroup "S6_PS_MPHASE_PI_CFG5 (at 0x12478)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S6_PS_MPHASE_PI_CFG6"
      sgroup "S6_PS_MPHASE_PI_CFG6 (at 0x12479)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S6_PS_CAL_FAULT"
      sgroup "S6_PS_CAL_FAULT (at 0x1247a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80247a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x247a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S6_PS_ADC_OUT"
      sgroup "S6_PS_ADC_OUT (at 0x1247b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80247b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x247b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S6_PS_MP_IAVG2"
      sgroup "S6_PS_MP_IAVG2 (at 0x1247c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80247c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x247c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S6_PS_MP_IAVG1"
      sgroup "S6_PS_MP_IAVG1 (at 0x1247d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80247d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x247d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S6_PS_MP_DAC_DATA"
      sgroup "S6_PS_MP_DAC_DATA (at 0x1247e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80247e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x247e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S6_PS_GANG_CTL1"
      sgroup "S6_PS_GANG_CTL1 (at 0x124c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S6_PS_GANG_CTL2"
      sgroup "S6_PS_GANG_CTL2 (at 0x124c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S6_PS_SEC_ACCESS"
      sgroup "S6_PS_SEC_ACCESS (at 0x124d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S6_PS_PERPH_RESET_CTL1"
      sgroup "S6_PS_PERPH_RESET_CTL1 (at 0x124d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL2"
      sgroup "S6_PS_PERPH_RESET_CTL2 (at 0x124d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL3"
      sgroup "S6_PS_PERPH_RESET_CTL3 (at 0x124da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S6_PS_PERPH_RESET_CTL4"
      sgroup "S6_PS_PERPH_RESET_CTL4 (at 0x124db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S6_PS_ATEST12"
      sgroup "S6_PS_ATEST12 (at 0x124e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_ATEST34"
      sgroup "S6_PS_ATEST34 (at 0x124e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S6_PS_DTEST12"
      sgroup "S6_PS_DTEST12 (at 0x124e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S6_PS_DTEST43"
      sgroup "S6_PS_DTEST43 (at 0x124e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S6_PS_TRIM_NUM"
      sgroup "S6_PS_TRIM_NUM (at 0x124f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S6_PS_ZX_TRIM"
      sgroup "S6_PS_ZX_TRIM (at 0x124f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S6_PS_CL_TRIM"
      sgroup "S6_PS_CL_TRIM (at 0x124f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S7_CTRL"
  tree "S7_CTRL"
    tree "S7_CTRL_REVISION1"
      sgroup "S7_CTRL_REVISION1 (at 0x12600)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_CTRL_REVISION2"
      sgroup "S7_CTRL_REVISION2 (at 0x12601)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_CTRL_REVISION3"
      sgroup "S7_CTRL_REVISION3 (at 0x12602)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_CTRL_REVISION4"
      sgroup "S7_CTRL_REVISION4 (at 0x12603)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_CTRL_PERPH_TYPE"
      sgroup "S7_CTRL_PERPH_TYPE (at 0x12604)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_CTRL_PERPH_SUBTYPE"
      sgroup "S7_CTRL_PERPH_SUBTYPE (at 0x12605)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_CTRL_STATUS_1"
      sgroup "S7_CTRL_STATUS_1 (at 0x12608)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S7_CTRL_STATUS_2"
      sgroup "S7_CTRL_STATUS_2 (at 0x12609)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S7_CTRL_STATUS_3"
      sgroup "S7_CTRL_STATUS_3 (at 0x1260a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80260a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x260a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S7_CTRL_STATUS_4"
      sgroup "S7_CTRL_STATUS_4 (at 0x1260b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80260b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x260b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_RT_STS"
      sgroup "S7_CTRL_INT_RT_STS (at 0x12610)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_SET_TYPE"
      sgroup "S7_CTRL_INT_SET_TYPE (at 0x12611)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_POLARITY_HIGH"
      sgroup "S7_CTRL_INT_POLARITY_HIGH (at 0x12612)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_POLARITY_LOW"
      sgroup "S7_CTRL_INT_POLARITY_LOW (at 0x12613)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_LATCHED_CLR"
      sgroup "S7_CTRL_INT_LATCHED_CLR (at 0x12614)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_EN_SET"
      sgroup "S7_CTRL_INT_EN_SET (at 0x12615)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_EN_CLR"
      sgroup "S7_CTRL_INT_EN_CLR (at 0x12616)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_LATCHED_STS"
      sgroup "S7_CTRL_INT_LATCHED_STS (at 0x12618)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_PENDING_STS"
      sgroup "S7_CTRL_INT_PENDING_STS (at 0x12619)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_MID_SEL"
      sgroup "S7_CTRL_INT_MID_SEL (at 0x1261a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80261a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x261a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_INT_PRIORITY"
      sgroup "S7_CTRL_INT_PRIORITY (at 0x1261b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80261b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x261b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL1"
      sgroup "S7_CTRL_VOLTAGE_CTL1 (at 0x12640)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL2"
      sgroup "S7_CTRL_VOLTAGE_CTL2 (at 0x12641)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S7_CTRL_VSET_VALID"
      sgroup "S7_CTRL_VSET_VALID (at 0x12642)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S7_CTRL_VOLTAGE_CTL3"
      sgroup "S7_CTRL_VOLTAGE_CTL3 (at 0x12644)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_MODE_CTL"
      sgroup "S7_CTRL_MODE_CTL (at 0x12645)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S7_CTRL_EN_CTL"
      sgroup "S7_CTRL_EN_CTL (at 0x12646)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S7_CTRL_PD_CTL"
      sgroup "S7_CTRL_PD_CTL (at 0x12648)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S7_CTRL_FREQ_CTL"
      sgroup "S7_CTRL_FREQ_CTL (at 0x12650)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S7_CTRL_MULTIPHASE_CTL"
      sgroup "S7_CTRL_MULTIPHASE_CTL (at 0x12651)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S7_CTRL_PHASE_CTL"
      sgroup "S7_CTRL_PHASE_CTL (at 0x12652)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_PHASE_ID"
      sgroup "S7_CTRL_PHASE_ID (at 0x12653)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_PHASE_CNT"
      sgroup "S7_CTRL_PHASE_CNT (at 0x12654)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_SS_CTL"
      sgroup "S7_CTRL_SS_CTL (at 0x12660)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_VS_CTL"
      sgroup "S7_CTRL_VS_CTL (at 0x12661)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CORR_CFG"
      sgroup "S7_CTRL_CORR_CFG (at 0x12662)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S7_CTRL_RAMP_CFG"
      sgroup "S7_CTRL_RAMP_CFG (at 0x12663)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_COMPENS_CFG"
      sgroup "S7_CTRL_COMPENS_CFG (at 0x12664)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_VREG_OK"
      sgroup "S7_CTRL_CFG_VREG_OK (at 0x12665)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_VREG_FAULT"
      sgroup "S7_CTRL_CFG_VREG_FAULT (at 0x12666)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_PFM_COMP"
      sgroup "S7_CTRL_CFG_PFM_COMP (at 0x12667)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S7_CTRL_UL_LL_CTL"
      sgroup "S7_CTRL_UL_LL_CTL (at 0x12668)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S7_CTRL_VSET_ULS"
      sgroup "S7_CTRL_VSET_ULS (at 0x12669)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S7_CTRL_ULS_VALID"
      sgroup "S7_CTRL_ULS_VALID (at 0x1266a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80266a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x266a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S7_CTRL_VSET_LLS"
      sgroup "S7_CTRL_VSET_LLS (at 0x1266b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80266b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x266b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S7_CTRL_LLS_VALID"
      sgroup "S7_CTRL_LLS_VALID (at 0x1266c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80266c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x266c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S7_CTRL_GPL_HI"
      sgroup "S7_CTRL_GPL_HI (at 0x1266d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80266d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x266d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S7_CTRL_GPL_LO"
      sgroup "S7_CTRL_GPL_LO (at 0x1266e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x80266e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x266e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S7_CTRL_CFG_ATEST1"
      sgroup "S7_CTRL_CFG_ATEST1 (at 0x126b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_ATEST2"
      sgroup "S7_CTRL_CFG_ATEST2 (at 0x126b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_ATEST3"
      sgroup "S7_CTRL_CFG_ATEST3 (at 0x126b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_ATEST4"
      sgroup "S7_CTRL_CFG_ATEST4 (at 0x126b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CFG_DTEST1"
      sgroup "S7_CTRL_CFG_DTEST1 (at 0x126b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_DTEST2"
      sgroup "S7_CTRL_CFG_DTEST2 (at 0x126b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_DTEST3"
      sgroup "S7_CTRL_CFG_DTEST3 (at 0x126b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_CTRL_CFG_DTEST4"
      sgroup "S7_CTRL_CFG_DTEST4 (at 0x126b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_GANG_CTL1"
      sgroup "S7_CTRL_GANG_CTL1 (at 0x126c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S7_CTRL_GANG_CTL2"
      sgroup "S7_CTRL_GANG_CTL2 (at 0x126c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S7_CTRL_SEC_ACCESS"
      sgroup "S7_CTRL_SEC_ACCESS (at 0x126d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL1"
      sgroup "S7_CTRL_PERPH_RESET_CTL1 (at 0x126d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL2"
      sgroup "S7_CTRL_PERPH_RESET_CTL2 (at 0x126d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL3"
      sgroup "S7_CTRL_PERPH_RESET_CTL3 (at 0x126da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_CTRL_PERPH_RESET_CTL4"
      sgroup "S7_CTRL_PERPH_RESET_CTL4 (at 0x126db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_TEST1"
      sgroup "S7_CTRL_INT_TEST1 (at 0x126e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S7_CTRL_INT_TEST_VAL"
      sgroup "S7_CTRL_INT_TEST_VAL (at 0x126e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S7_CTRL_MODE_FSM_MASK"
      sgroup "S7_CTRL_MODE_FSM_MASK (at 0x126e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S7_CTRL_GATE_DRV_MUX"
      sgroup "S7_CTRL_GATE_DRV_MUX (at 0x126e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_CORR_DUTY_MUX"
      sgroup "S7_CTRL_CORR_DUTY_MUX (at 0x126e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S7_CTRL_EN_OPTIONS_DFT"
      sgroup "S7_CTRL_EN_OPTIONS_DFT (at 0x126e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S7_CTRL_CAL_CTL"
      sgroup "S7_CTRL_CAL_CTL (at 0x126e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S7_CTRL_IDAC_CAL_VAL"
      sgroup "S7_CTRL_IDAC_CAL_VAL (at 0x126e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S7_CTRL_CORR_CAL_VAL"
      sgroup "S7_CTRL_CORR_CAL_VAL (at 0x126ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S7_CTRL_PWM_CAL_VAL"
      sgroup "S7_CTRL_PWM_CAL_VAL (at 0x126eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S7_CTRL_PFM_CAL_VAL"
      sgroup "S7_CTRL_PFM_CAL_VAL (at 0x126ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S7_CTRL_MPHASE_IDAC"
      sgroup "S7_CTRL_MPHASE_IDAC (at 0x126ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S7_CTRL_TRIM_NUM"
      sgroup "S7_CTRL_TRIM_NUM (at 0x126f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S7_CTRL_CAL_EN_TRIM"
      sgroup "S7_CTRL_CAL_EN_TRIM (at 0x126f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S7_CTRL_REFDAC_TRIM"
      sgroup "S7_CTRL_REFDAC_TRIM (at 0x126f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S7_CTRL_IDAC_TRIM"
      sgroup "S7_CTRL_IDAC_TRIM (at 0x126f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S7_CTRL_CORR_TRIM"
      sgroup "S7_CTRL_CORR_TRIM (at 0x126f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S7_CTRL_PWM_TRIM"
      sgroup "S7_CTRL_PWM_TRIM (at 0x126f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S7_CTRL_PFM_TRIM"
      sgroup "S7_CTRL_PFM_TRIM (at 0x126f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S7_CTRL_RAMP_TRIM"
      sgroup "S7_CTRL_RAMP_TRIM (at 0x126f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        set &access:&cmd_addr %l 0x8026f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x26f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S7_FREQ"
  tree "S7_FREQ"
    tree "S7_FREQ_REVISION1"
      sgroup "S7_FREQ_REVISION1 (at 0x12800)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_FREQ_REVISION2"
      sgroup "S7_FREQ_REVISION2 (at 0x12801)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_FREQ_REVISION3"
      sgroup "S7_FREQ_REVISION3 (at 0x12802)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_FREQ_REVISION4"
      sgroup "S7_FREQ_REVISION4 (at 0x12803)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_FREQ_PERPH_TYPE"
      sgroup "S7_FREQ_PERPH_TYPE (at 0x12804)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_FREQ_PERPH_SUBTYPE"
      sgroup "S7_FREQ_PERPH_SUBTYPE (at 0x12805)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_FREQ_CLK_ENABLE"
      sgroup "S7_FREQ_CLK_ENABLE (at 0x12846)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S7_FREQ_CLK_DIV"
      sgroup "S7_FREQ_CLK_DIV (at 0x12850)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S7_FREQ_CLK_PHASE"
      sgroup "S7_FREQ_CLK_PHASE (at 0x12851)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S7_FREQ_GANG_CTL1"
      sgroup "S7_FREQ_GANG_CTL1 (at 0x128c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S7_FREQ_GANG_CTL2"
      sgroup "S7_FREQ_GANG_CTL2 (at 0x128c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S7_FREQ_SEC_ACCESS"
      sgroup "S7_FREQ_SEC_ACCESS (at 0x128d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL2"
      sgroup "S7_FREQ_PERPH_RESET_CTL2 (at 0x128d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL3"
      sgroup "S7_FREQ_PERPH_RESET_CTL3 (at 0x128da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_FREQ_PERPH_RESET_CTL4"
      sgroup "S7_FREQ_PERPH_RESET_CTL4 (at 0x128db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S7_FREQ_TEST1"
      sgroup "S7_FREQ_TEST1 (at 0x128e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        set &access:&cmd_addr %l 0x8028e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2800
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x28e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S7_PS"
  tree "S7_PS"
    tree "S7_PS_REVISION1"
      sgroup "S7_PS_REVISION1 (at 0x12700)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S7_PS_REVISION2"
      sgroup "S7_PS_REVISION2 (at 0x12701)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S7_PS_REVISION3"
      sgroup "S7_PS_REVISION3 (at 0x12702)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S7_PS_REVISION4"
      sgroup "S7_PS_REVISION4 (at 0x12703)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S7_PS_PERPH_TYPE"
      sgroup "S7_PS_PERPH_TYPE (at 0x12704)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S7_PS_PERPH_SUBTYPE"
      sgroup "S7_PS_PERPH_SUBTYPE (at 0x12705)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S7_PS_VOLTAGE_CTL1"
      sgroup "S7_PS_VOLTAGE_CTL1 (at 0x12740)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S7_PS_VOLTAGE_CTL2"
      sgroup "S7_PS_VOLTAGE_CTL2 (at 0x12741)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S7_PS_FREQ_CTL"
      sgroup "S7_PS_FREQ_CTL (at 0x12750)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S7_PS_MULTIPHASE_CTL"
      sgroup "S7_PS_MULTIPHASE_CTL (at 0x12751)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S7_PS_PHASE_CTL"
      sgroup "S7_PS_PHASE_CTL (at 0x12752)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_PHASE_ID"
      sgroup "S7_PS_PHASE_ID (at 0x12753)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_PHASE_CNT"
      sgroup "S7_PS_PHASE_CNT (at 0x12754)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_PWM_CL_CTL"
      sgroup "S7_PS_PWM_CL_CTL (at 0x12760)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_PS_LPM_CL_CTL"
      sgroup "S7_PS_LPM_CL_CTL (at 0x12761)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_PS_AUTO_CTL"
      sgroup "S7_PS_AUTO_CTL (at 0x12762)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S7_PS_FSM_MINON_CFG"
      sgroup "S7_PS_FSM_MINON_CFG (at 0x12770)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_ICOMP_EN_CFG"
      sgroup "S7_PS_ICOMP_EN_CFG (at 0x12771)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_ZX_CAL_CFG"
      sgroup "S7_PS_ZX_CAL_CFG (at 0x12772)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_NONOVLAP_CFG"
      sgroup "S7_PS_NONOVLAP_CFG (at 0x12773)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_MPHASE_PI_CFG1"
      sgroup "S7_PS_MPHASE_PI_CFG1 (at 0x12774)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG2"
      sgroup "S7_PS_MPHASE_PI_CFG2 (at 0x12775)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG3"
      sgroup "S7_PS_MPHASE_PI_CFG3 (at 0x12776)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG4"
      sgroup "S7_PS_MPHASE_PI_CFG4 (at 0x12777)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG5"
      sgroup "S7_PS_MPHASE_PI_CFG5 (at 0x12778)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S7_PS_MPHASE_PI_CFG6"
      sgroup "S7_PS_MPHASE_PI_CFG6 (at 0x12779)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S7_PS_CAL_FAULT"
      sgroup "S7_PS_CAL_FAULT (at 0x1277a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x80277a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x277a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S7_PS_ADC_OUT"
      sgroup "S7_PS_ADC_OUT (at 0x1277b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x80277b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x277b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S7_PS_MP_IAVG2"
      sgroup "S7_PS_MP_IAVG2 (at 0x1277c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x80277c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x277c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S7_PS_MP_IAVG1"
      sgroup "S7_PS_MP_IAVG1 (at 0x1277d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x80277d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x277d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S7_PS_MP_DAC_DATA"
      sgroup "S7_PS_MP_DAC_DATA (at 0x1277e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x80277e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x277e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S7_PS_GANG_CTL1"
      sgroup "S7_PS_GANG_CTL1 (at 0x127c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S7_PS_GANG_CTL2"
      sgroup "S7_PS_GANG_CTL2 (at 0x127c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S7_PS_SEC_ACCESS"
      sgroup "S7_PS_SEC_ACCESS (at 0x127d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S7_PS_PERPH_RESET_CTL1"
      sgroup "S7_PS_PERPH_RESET_CTL1 (at 0x127d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL2"
      sgroup "S7_PS_PERPH_RESET_CTL2 (at 0x127d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL3"
      sgroup "S7_PS_PERPH_RESET_CTL3 (at 0x127da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S7_PS_PERPH_RESET_CTL4"
      sgroup "S7_PS_PERPH_RESET_CTL4 (at 0x127db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S7_PS_ATEST12"
      sgroup "S7_PS_ATEST12 (at 0x127e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_ATEST34"
      sgroup "S7_PS_ATEST34 (at 0x127e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S7_PS_DTEST12"
      sgroup "S7_PS_DTEST12 (at 0x127e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S7_PS_DTEST43"
      sgroup "S7_PS_DTEST43 (at 0x127e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S7_PS_TRIM_NUM"
      sgroup "S7_PS_TRIM_NUM (at 0x127f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S7_PS_ZX_TRIM"
      sgroup "S7_PS_ZX_TRIM (at 0x127f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S7_PS_CL_TRIM"
      sgroup "S7_PS_CL_TRIM (at 0x127f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        set &access:&cmd_addr %l 0x8027f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2700
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x27f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "S8_CTRL"
  tree "S8_CTRL"
    tree "S8_CTRL_REVISION1"
      sgroup "S8_CTRL_REVISION1 (at 0x12900)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_CTRL_REVISION2"
      sgroup "S8_CTRL_REVISION2 (at 0x12901)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_CTRL_REVISION3"
      sgroup "S8_CTRL_REVISION3 (at 0x12902)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_CTRL_REVISION4"
      sgroup "S8_CTRL_REVISION4 (at 0x12903)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_CTRL_PERPH_TYPE"
      sgroup "S8_CTRL_PERPH_TYPE (at 0x12904)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_CTRL_PERPH_SUBTYPE"
      sgroup "S8_CTRL_PERPH_SUBTYPE (at 0x12905)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_CTRL_STATUS_1"
      sgroup "S8_CTRL_STATUS_1 (at 0x12908)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VREG_OK_FLAG                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   VREG_FAULT_FLAG                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   NPM_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   STEPPER_DONE_FLAG                        = " "0, 1"
    tree.end
    tree "S8_CTRL_STATUS_2"
      sgroup "S8_CTRL_STATUS_2 (at 0x12909)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   ILS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ULS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   LLS_FLAG                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   GPL_HI_FLAG                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GPL_LO_FLAG                              = " "0, 1"
    tree.end
    tree "S8_CTRL_STATUS_3"
      sgroup "S8_CTRL_STATUS_3 (at 0x1290a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80290a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x290a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   IDAC_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CORR_CAL_FAULT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   PWM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   PFM_CAL_FAULT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PS_CAL_DONE_FLAG                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   CAL_DONE_FLAG                            = " "0, 1"
    tree.end
    tree "S8_CTRL_STATUS_4"
      sgroup "S8_CTRL_STATUS_4 (at 0x1290b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80290b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x290b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   MODE_FSM_3                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   MODE_FSM_2                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   MODE_FSM_1                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MODE_FSM_0                               = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_RT_STS"
      sgroup "S8_CTRL_INT_RT_STS (at 0x12910)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_SET_TYPE"
      sgroup "S8_CTRL_INT_SET_TYPE (at 0x12911)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_POLARITY_HIGH"
      sgroup "S8_CTRL_INT_POLARITY_HIGH (at 0x12912)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_POLARITY_LOW"
      sgroup "S8_CTRL_INT_POLARITY_LOW (at 0x12913)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_LATCHED_CLR"
      sgroup "S8_CTRL_INT_LATCHED_CLR (at 0x12914)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_EN_SET"
      sgroup "S8_CTRL_INT_EN_SET (at 0x12915)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_EN_CLR"
      sgroup "S8_CTRL_INT_EN_CLR (at 0x12916)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_LATCHED_STS"
      sgroup "S8_CTRL_INT_LATCHED_STS (at 0x12918)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_PENDING_STS"
      sgroup "S8_CTRL_INT_PENDING_STS (at 0x12919)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT                              = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_MID_SEL"
      sgroup "S8_CTRL_INT_MID_SEL (at 0x1291a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80291a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x291a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_INT_PRIORITY"
      sgroup "S8_CTRL_INT_PRIORITY (at 0x1291b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80291b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x291b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL1"
      sgroup "S8_CTRL_VOLTAGE_CTL1 (at 0x12940)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL2"
      sgroup "S8_CTRL_VOLTAGE_CTL2 (at 0x12941)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S8_CTRL_VSET_VALID"
      sgroup "S8_CTRL_VSET_VALID (at 0x12942)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29420
      line.byte 0x0 "VALUE"
