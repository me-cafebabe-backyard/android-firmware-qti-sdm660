      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_VALID                               = "
    tree.end
    tree "S8_CTRL_VOLTAGE_CTL3"
      sgroup "S8_CTRL_VOLTAGE_CTL3 (at 0x12944)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PFM_VOFFSET_EN                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PFM_VOFFSET                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_MODE_CTL"
      sgroup "S8_CTRL_MODE_CTL (at 0x12945)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   NPM                                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   AUTO_MODE                                = " "0, 1"
    tree.end
    tree "S8_CTRL_EN_CTL"
      sgroup "S8_CTRL_EN_CTL (at 0x12946)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PERPH_EN                                 = " "0, 1"
    tree.end
    tree "S8_CTRL_PD_CTL"
      sgroup "S8_CTRL_PD_CTL (at 0x12948)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029480
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29480
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PD_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   WEAK_PD_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   WEAK_PD_PFM                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   WEAK_PD_PWM                              = " "0, 1"
    tree.end
    tree "S8_CTRL_FREQ_CTL"
      sgroup "S8_CTRL_FREQ_CTL (at 0x12950)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S8_CTRL_MULTIPHASE_CTL"
      sgroup "S8_CTRL_MULTIPHASE_CTL (at 0x12951)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S8_CTRL_PHASE_CTL"
      sgroup "S8_CTRL_PHASE_CTL (at 0x12952)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_PHASE_ID"
      sgroup "S8_CTRL_PHASE_ID (at 0x12953)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_PHASE_CNT"
      sgroup "S8_CTRL_PHASE_CNT (at 0x12954)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_SS_CTL"
      sgroup "S8_CTRL_SS_CTL (at 0x12960)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   SS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   SS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_VS_CTL"
      sgroup "S8_CTRL_VS_CTL (at 0x12961)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   VS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   VS_STEP                                  = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   VS_DELAY                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CORR_CFG"
      sgroup "S8_CTRL_CORR_CFG (at 0x12962)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x6 "  [ 6: 4]   CORR_MAG_CFG                             = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CORR_FILT_CFG                            = "
    tree.end
    tree "S8_CTRL_RAMP_CFG"
      sgroup "S8_CTRL_RAMP_CFG (at 0x12963)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029630
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29630
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   RAMP_COMPENS_CFG                         = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   RAMP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_COMPENS_CFG"
      sgroup "S8_CTRL_COMPENS_CFG (at 0x12964)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029640
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29640
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x4 "  [ 4: 3]   BPHP_CFG                                 = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   BPLP_CFG                                 = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_VREG_OK"
      sgroup "S8_CTRL_CFG_VREG_OK (at 0x12965)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029650
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29650
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_OK                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_VREG_FAULT"
      sgroup "S8_CTRL_CFG_VREG_FAULT (at 0x12966)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029660
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29660
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_VREG_FAULT                           = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_PFM_COMP"
      sgroup "S8_CTRL_CFG_PFM_COMP (at 0x12967)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029670
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29670
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_HYS                                  = " "0, 1"
    tree.end
    tree "S8_CTRL_UL_LL_CTL"
      sgroup "S8_CTRL_UL_LL_CTL (at 0x12968)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029680
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29680
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   UL_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   LL_EN                                    = " "0, 1"
    tree.end
    tree "S8_CTRL_VSET_ULS"
      sgroup "S8_CTRL_VSET_ULS (at 0x12969)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029690
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29690
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_ULS                                 = "
    tree.end
    tree "S8_CTRL_ULS_VALID"
      sgroup "S8_CTRL_ULS_VALID (at 0x1296a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80296a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x296a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ULS_VALID                                = "
    tree.end
    tree "S8_CTRL_VSET_LLS"
      sgroup "S8_CTRL_VSET_LLS (at 0x1296b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80296b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x296b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_LLS                                 = "
    tree.end
    tree "S8_CTRL_LLS_VALID"
      sgroup "S8_CTRL_LLS_VALID (at 0x1296c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80296c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x296c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   LLS_VALID                                = "
    tree.end
    tree "S8_CTRL_GPL_HI"
      sgroup "S8_CTRL_GPL_HI (at 0x1296d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80296d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x296d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_HI                              = "
    tree.end
    tree "S8_CTRL_GPL_LO"
      sgroup "S8_CTRL_GPL_LO (at 0x1296e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x80296e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x296e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET_GPL_LO                              = "
    tree.end
    tree "S8_CTRL_CFG_ATEST1"
      sgroup "S8_CTRL_CFG_ATEST1 (at 0x129b0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_ATEST2"
      sgroup "S8_CTRL_CFG_ATEST2 (at 0x129b1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_ATEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_ATEST3"
      sgroup "S8_CTRL_CFG_ATEST3 (at 0x129b2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST3                               = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_ATEST4"
      sgroup "S8_CTRL_CFG_ATEST4 (at 0x129b3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_ATEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CFG_DTEST1"
      sgroup "S8_CTRL_CFG_DTEST1 (at 0x129b4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST1                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_DTEST2"
      sgroup "S8_CTRL_CFG_DTEST2 (at 0x129b5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST2                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_DTEST3"
      sgroup "S8_CTRL_CFG_DTEST3 (at 0x129b6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CFG_DTEST3                               = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_CTRL_CFG_DTEST4"
      sgroup "S8_CTRL_CFG_DTEST4 (at 0x129b7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029b70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29b70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CFG_DTEST4                               = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_GANG_CTL1"
      sgroup "S8_CTRL_GANG_CTL1 (at 0x129c0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029c00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29c00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_CTRL_GANG_CTL2"
      sgroup "S8_CTRL_GANG_CTL2 (at 0x129c1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029c10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29c10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S8_CTRL_SEC_ACCESS"
      sgroup "S8_CTRL_SEC_ACCESS (at 0x129d0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL1"
      sgroup "S8_CTRL_PERPH_RESET_CTL1 (at 0x129d8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL2"
      sgroup "S8_CTRL_PERPH_RESET_CTL2 (at 0x129d9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL3"
      sgroup "S8_CTRL_PERPH_RESET_CTL3 (at 0x129da)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_CTRL_PERPH_RESET_CTL4"
      sgroup "S8_CTRL_PERPH_RESET_CTL4 (at 0x129db)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_TEST1"
      sgroup "S8_CTRL_INT_TEST1 (at 0x129e0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "S8_CTRL_INT_TEST_VAL"
      sgroup "S8_CTRL_INT_TEST_VAL (at 0x129e1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   VREG_FAULT_INT_TEST_VAL                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   LIMIT_ERR_INT_TEST_VAL                   = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   VREG_OK_INT_TEST_VAL                     = " "0, 1"
    tree.end
    tree "S8_CTRL_MODE_FSM_MASK"
      sgroup "S8_CTRL_MODE_FSM_MASK (at 0x129e2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MODE_FSM_MASK_EN                         = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   MODE_FSM_MASK_VALUE                      = "
    tree.end
    tree "S8_CTRL_GATE_DRV_MUX"
      sgroup "S8_CTRL_GATE_DRV_MUX (at 0x129e3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   GATE_DRV_MUX1                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   GATE_DRV_MUX2                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   GATE_DRV_MUX3                            = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_CORR_DUTY_MUX"
      sgroup "S8_CTRL_CORR_DUTY_MUX (at 0x129e4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   CORR_DUTY_MUX                            = " "0, 1, 2, 3"
    tree.end
    tree "S8_CTRL_EN_OPTIONS_DFT"
      sgroup "S8_CTRL_EN_OPTIONS_DFT (at 0x129e5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   SS_EN                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   CORR_SHIFT_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   SAMPLE_CLK_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   SAMPLE_AMP_TRI                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   RAMP_EN                                  = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   COMPENS_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   SAMPLE_PREBIAS_EN                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   GDRV_EN                                  = " "0, 1"
    tree.end
    tree "S8_CTRL_CAL_CTL"
      sgroup "S8_CTRL_CAL_CTL (at 0x129e8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   CAL_REQUEST                              = " "0, 1"
    tree.end
    tree "S8_CTRL_IDAC_CAL_VAL"
      sgroup "S8_CTRL_IDAC_CAL_VAL (at 0x129e9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029e90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29e90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_CAL_VAL                             = "
    tree.end
    tree "S8_CTRL_CORR_CAL_VAL"
      sgroup "S8_CTRL_CORR_CAL_VAL (at 0x129ea)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029ea0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29ea0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_CAL_VAL                             = "
    tree.end
    tree "S8_CTRL_PWM_CAL_VAL"
      sgroup "S8_CTRL_PWM_CAL_VAL (at 0x129eb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029eb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29eb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   PWM_CAL_VAL                              = "
    tree.end
    tree "S8_CTRL_PFM_CAL_VAL"
      sgroup "S8_CTRL_PFM_CAL_VAL (at 0x129ec)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029ec0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29ec0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_CAL_VAL                              = "
    tree.end
    tree "S8_CTRL_MPHASE_IDAC"
      sgroup "S8_CTRL_MPHASE_IDAC (at 0x129ed)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029ed0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29ed0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVR_EN                                   = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   DATA                                     = "
    tree.end
    tree "S8_CTRL_TRIM_NUM"
      sgroup "S8_CTRL_TRIM_NUM (at 0x129f0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S8_CTRL_CAL_EN_TRIM"
      sgroup "S8_CTRL_CAL_EN_TRIM (at 0x129f1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   IDAC_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   CORR_CAL_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   PWM_CAL_EN                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   PFM_CAL_EN                               = " "0, 1"
    tree.end
    tree "S8_CTRL_REFDAC_TRIM"
      sgroup "S8_CTRL_REFDAC_TRIM (at 0x129f2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   REFDAC_TRIM_EN                           = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   REFDAC_TRIM                              = "
    tree.end
    tree "S8_CTRL_IDAC_TRIM"
      sgroup "S8_CTRL_IDAC_TRIM (at 0x129f3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   IDAC_TRIM                                = "
    tree.end
    tree "S8_CTRL_CORR_TRIM"
      sgroup "S8_CTRL_CORR_TRIM (at 0x129f4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   CORR_TRIM                                = "
    tree.end
    tree "S8_CTRL_PWM_TRIM"
      sgroup "S8_CTRL_PWM_TRIM (at 0x129f5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   PWM_P_TRIM                               = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PWM_N_TRIM                               = "
    tree.end
    tree "S8_CTRL_PFM_TRIM"
      sgroup "S8_CTRL_PFM_TRIM (at 0x129f6)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   PFM_TRIM                                 = "
    tree.end
    tree "S8_CTRL_RAMP_TRIM"
      sgroup "S8_CTRL_RAMP_TRIM (at 0x129f7)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        set &access:&cmd_addr %l 0x8029f70
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2900
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x29f70
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   RAMP_TRIM                                = "
    tree.end
  tree.end
tree.end
tree "S8_FREQ"
  tree "S8_FREQ"
    tree "S8_FREQ_REVISION1"
      sgroup "S8_FREQ_REVISION1 (at 0x12b00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_FREQ_REVISION2"
      sgroup "S8_FREQ_REVISION2 (at 0x12b01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_FREQ_REVISION3"
      sgroup "S8_FREQ_REVISION3 (at 0x12b02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_FREQ_REVISION4"
      sgroup "S8_FREQ_REVISION4 (at 0x12b03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_FREQ_PERPH_TYPE"
      sgroup "S8_FREQ_PERPH_TYPE (at 0x12b04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_FREQ_PERPH_SUBTYPE"
      sgroup "S8_FREQ_PERPH_SUBTYPE (at 0x12b05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_FREQ_CLK_ENABLE"
      sgroup "S8_FREQ_CLK_ENABLE (at 0x12b46)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_CLK_INT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_CLK_SX_REQ                        = " "0, 1"
    tree.end
    tree "S8_FREQ_CLK_DIV"
      sgroup "S8_FREQ_CLK_DIV (at 0x12b50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_DIV                                  = "
    tree.end
    tree "S8_FREQ_CLK_PHASE"
      sgroup "S8_FREQ_CLK_PHASE (at 0x12b51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802b510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2b510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   CLK_PHASE                                = "
    tree.end
    tree "S8_FREQ_GANG_CTL1"
      sgroup "S8_FREQ_GANG_CTL1 (at 0x12bc0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802bc00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2bc00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_FREQ_GANG_CTL2"
      sgroup "S8_FREQ_GANG_CTL2 (at 0x12bc1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802bc10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2bc10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S8_FREQ_SEC_ACCESS"
      sgroup "S8_FREQ_SEC_ACCESS (at 0x12bd0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802bd00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2bd00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL2"
      sgroup "S8_FREQ_PERPH_RESET_CTL2 (at 0x12bd9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802bd90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2bd90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL3"
      sgroup "S8_FREQ_PERPH_RESET_CTL3 (at 0x12bda)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802bda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2bda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_FREQ_PERPH_RESET_CTL4"
      sgroup "S8_FREQ_PERPH_RESET_CTL4 (at 0x12bdb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802bdb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2bdb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S8_FREQ_TEST1"
      sgroup "S8_FREQ_TEST1 (at 0x12be2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        set &access:&cmd_addr %l 0x802be20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2b00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2be20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   EN_DTEST                                 = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x6 "  [ 6: 5]   DTEST                                    = " "0, 1, 2, 3"
    tree.end
  tree.end
tree.end
tree "S8_PS"
  tree "S8_PS"
    tree "S8_PS_REVISION1"
      sgroup "S8_PS_REVISION1 (at 0x12a00)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "S8_PS_REVISION2"
      sgroup "S8_PS_REVISION2 (at 0x12a01)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "S8_PS_REVISION3"
      sgroup "S8_PS_REVISION3 (at 0x12a02)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "S8_PS_REVISION4"
      sgroup "S8_PS_REVISION4 (at 0x12a03)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "S8_PS_PERPH_TYPE"
      sgroup "S8_PS_PERPH_TYPE (at 0x12a04)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "S8_PS_PERPH_SUBTYPE"
      sgroup "S8_PS_PERPH_SUBTYPE (at 0x12a05)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "S8_PS_VOLTAGE_CTL1"
      sgroup "S8_PS_VOLTAGE_CTL1 (at 0x12a40)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MV_RANGE                                 = " "0, 1"
    tree.end
    tree "S8_PS_VOLTAGE_CTL2"
      sgroup "S8_PS_VOLTAGE_CTL2 (at 0x12a41)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a410
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a410
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   VSET                                     = "
    tree.end
    tree "S8_PS_FREQ_CTL"
      sgroup "S8_PS_FREQ_CTL (at 0x12a50)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a500
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a500
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   FREQ_CTL                                 = "
    tree.end
    tree "S8_PS_MULTIPHASE_CTL"
      sgroup "S8_PS_MULTIPHASE_CTL (at 0x12a51)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a510
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a510
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   MULTIPHASE_EN                            = " "0, 1"
    tree.end
    tree "S8_PS_PHASE_CTL"
      sgroup "S8_PS_PHASE_CTL (at 0x12a52)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a520
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a520
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   PHASE_BALANCE_EN                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_STANDBY_MODE                       = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_PHASE_ID"
      sgroup "S8_PS_PHASE_ID (at 0x12a53)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a530
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a530
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_ID                                 = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_PHASE_CNT"
      sgroup "S8_PS_PHASE_CNT (at 0x12a54)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a540
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a540
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PHASE_CNT                                = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_PWM_CL_CTL"
      sgroup "S8_PS_PWM_CL_CTL (at 0x12a60)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a600
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a600
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   PWM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_PS_LPM_CL_CTL"
      sgroup "S8_PS_LPM_CL_CTL (at 0x12a61)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a610
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a610
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_CL                                   = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_PS_AUTO_CTL"
      sgroup "S8_PS_AUTO_CTL (at 0x12a62)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a620
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a620
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x5 "  [ 5: 3]   LPM_EXIT_CYCLES                          = " "0, 1, 2, 3, 4, 5, 6, 7"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   LPM_ENTRY_CYCLES                         = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
    tree "S8_PS_FSM_MINON_CFG"
      sgroup "S8_PS_FSM_MINON_CFG (at 0x12a70)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a700
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a700
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   CL_EXTEND_BLANK                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   N_MIN_ON_TIME                            = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   P_MIN_ON_TIME                            = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_ICOMP_EN_CFG"
      sgroup "S8_PS_ICOMP_EN_CFG (at 0x12a71)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a710
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a710
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   EN_CL                                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   EN_ZX                                    = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_ZX_CAL_CFG"
      sgroup "S8_PS_ZX_CAL_CFG (at 0x12a72)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a720
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a720
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x2--0x7 1 "  [ 7: 2]   ZX_VOS_NOM                               = "
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ZX_CAL                                   = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_NONOVLAP_CFG"
      sgroup "S8_PS_NONOVLAP_CFG (at 0x12a73)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a730
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a730
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   NDRV_ON_DEL                              = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   PDRV_ON_DEL                              = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_MPHASE_PI_CFG1"
      sgroup "S8_PS_MPHASE_PI_CFG1 (at 0x12a74)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a740
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a740
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_LO                         = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG2"
      sgroup "S8_PS_MPHASE_PI_CFG2 (at 0x12a75)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a750
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a750
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_MID                        = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG3"
      sgroup "S8_PS_MPHASE_PI_CFG3 (at 0x12a76)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a760
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a760
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   A_COEFFICIENT_HI                         = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG4"
      sgroup "S8_PS_MPHASE_PI_CFG4 (at 0x12a77)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a770
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a770
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_LO                         = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG5"
      sgroup "S8_PS_MPHASE_PI_CFG5 (at 0x12a78)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a780
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a780
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_MID                        = "
    tree.end
    tree "S8_PS_MPHASE_PI_CFG6"
      sgroup "S8_PS_MPHASE_PI_CFG6 (at 0x12a79)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a790
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a790
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   B_COEFFICIENT_HI                         = "
    tree.end
    tree "S8_PS_CAL_FAULT"
      sgroup "S8_PS_CAL_FAULT (at 0x12a7a)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a7a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a7a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ZX_CAL_FAULT                             = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_CAL_VAL                               = "
    tree.end
    tree "S8_PS_ADC_OUT"
      sgroup "S8_PS_ADC_OUT (at 0x12a7b)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a7b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a7b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x6 1 "  [ 6: 0]   ADC_OUT                                  = "
    tree.end
    tree "S8_PS_MP_IAVG2"
      sgroup "S8_PS_MP_IAVG2 (at 0x12a7c)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a7c0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a7c0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   MP_IAVG_0                                = " "0, 1"
    tree.end
    tree "S8_PS_MP_IAVG1"
      sgroup "S8_PS_MP_IAVG1 (at 0x12a7d)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a7d0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a7d0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   MP_IAVG_8_1                              = "
    tree.end
    tree "S8_PS_MP_DAC_DATA"
      sgroup "S8_PS_MP_DAC_DATA (at 0x12a7e)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802a7e0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2a7e0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   MP_DAC_DATA                              = "
    tree.end
    tree "S8_PS_GANG_CTL1"
      sgroup "S8_PS_GANG_CTL1 (at 0x12ac0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ac00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ac00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   GANG_LEADER_PID                          = "
    tree.end
    tree "S8_PS_GANG_CTL2"
      sgroup "S8_PS_GANG_CTL2 (at 0x12ac1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ac10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ac10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   GANG_EN                                  = " "0, 1"
    tree.end
    tree "S8_PS_SEC_ACCESS"
      sgroup "S8_PS_SEC_ACCESS (at 0x12ad0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ad00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ad00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "S8_PS_PERPH_RESET_CTL1"
      sgroup "S8_PS_PERPH_RESET_CTL1 (at 0x12ad8)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ad80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ad80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL2"
      sgroup "S8_PS_PERPH_RESET_CTL2 (at 0x12ad9)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ad90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ad90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL3"
      sgroup "S8_PS_PERPH_RESET_CTL3 (at 0x12ada)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ada0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ada0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "S8_PS_PERPH_RESET_CTL4"
      sgroup "S8_PS_PERPH_RESET_CTL4 (at 0x12adb)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802adb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2adb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "S8_PS_ATEST12"
      sgroup "S8_PS_ATEST12 (at 0x12ae2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ae20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ae20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST2                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST1                                   = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_ATEST34"
      sgroup "S8_PS_ATEST34 (at 0x12ae3)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ae30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ae30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x3 "  [ 3: 2]   ATEST4                                   = " "0, 1, 2, 3"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST3                                   = " "0, 1, 2, 3"
    tree.end
    tree "S8_PS_DTEST12"
      sgroup "S8_PS_DTEST12 (at 0x12ae4)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ae40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ae40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST2                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST1                                   = "
    tree.end
    tree "S8_PS_DTEST43"
      sgroup "S8_PS_DTEST43 (at 0x12ae5)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802ae50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2ae50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST4                                   = "
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST3                                   = "
    tree.end
    tree "S8_PS_TRIM_NUM"
      sgroup "S8_PS_TRIM_NUM (at 0x12af0)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802af00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2af00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   NUM_TRIM                                 = "
    tree.end
    tree "S8_PS_ZX_TRIM"
      sgroup "S8_PS_ZX_TRIM (at 0x12af1)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802af10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2af10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   ZX_TRIM                                  = "
    tree.end
    tree "S8_PS_CL_TRIM"
      sgroup "S8_PS_CL_TRIM (at 0x12af2)"
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        set &access:&cmd_addr %l 0x802af20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x1)<<16.)|0x2a00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x2af20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   CL_TRIM                                  = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI"
  tree "SPMI"
    tree "SPMI_REVISION1"
      sgroup "SPMI_REVISION1 (at 0x600)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "SPMI_REVISION2"
      sgroup "SPMI_REVISION2 (at 0x601)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "SPMI_REVISION3"
      sgroup "SPMI_REVISION3 (at 0x602)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "SPMI_REVISION4"
      sgroup "SPMI_REVISION4 (at 0x603)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "SPMI_PERPH_TYPE"
      sgroup "SPMI_PERPH_TYPE (at 0x604)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "SPMI_PERPH_SUBTYPE"
      sgroup "SPMI_PERPH_SUBTYPE (at 0x605)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "SPMI_ERROR_SYNDROME"
      sgroup "SPMI_ERROR_SYNDROME (at 0x608)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ERROR_SYNDROME                           = "
    tree.end
    tree "SPMI_INT_RT_STS"
      sgroup "SPMI_INT_RT_STS (at 0x610)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_RT_STS                          = " "0, 1"
    tree.end
    tree "SPMI_INT_SET_TYPE"
      sgroup "SPMI_INT_SET_TYPE (at 0x611)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TYPE                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_HIGH"
      sgroup "SPMI_INT_POLARITY_HIGH (at 0x612)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_HIGH                            = " "0, 1"
    tree.end
    tree "SPMI_INT_POLARITY_LOW"
      sgroup "SPMI_INT_POLARITY_LOW (at 0x613)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LOW                             = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_CLR"
      sgroup "SPMI_INT_LATCHED_CLR (at 0x614)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_CLR                     = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_SET"
      sgroup "SPMI_INT_EN_SET (at 0x615)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_SET                          = " "0, 1"
    tree.end
    tree "SPMI_INT_EN_CLR"
      sgroup "SPMI_INT_EN_CLR (at 0x616)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_EN_CLR                          = " "0, 1"
    tree.end
    tree "SPMI_INT_LATCHED_STS"
      sgroup "SPMI_INT_LATCHED_STS (at 0x618)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_LATCHED_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_PENDING_STS"
      sgroup "SPMI_INT_PENDING_STS (at 0x619)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_PENDING_STS                     = " "0, 1"
    tree.end
    tree "SPMI_INT_MID_SEL"
      sgroup "SPMI_INT_MID_SEL (at 0x61a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "SPMI_INT_PRIORITY"
      sgroup "SPMI_INT_PRIORITY (at 0x61b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x80061b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x61b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "SPMI_SPMI_BUF_CFG"
      sgroup "SPMI_SPMI_BUF_CFG (at 0x640)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   BUFFER_STRENGTH                          = " "0 (LOW10PF),1 (MID20PF),2 (HIGH40PF),3 (VERYHIGH50PF)"
    tree.end
    tree "SPMI_SEC_ACCESS"
      sgroup "SPMI_SEC_ACCESS (at 0x6d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "SPMI_PERPH_RESET_CTL2"
      sgroup "SPMI_PERPH_RESET_CTL2 (at 0x6d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "SPMI_PERPH_RESET_CTL3"
      sgroup "SPMI_PERPH_RESET_CTL3 (at 0x6da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "SPMI_PERPH_RESET_CTL4"
      sgroup "SPMI_PERPH_RESET_CTL4 (at 0x6db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "SPMI_INT_TEST1"
      sgroup "SPMI_INT_TEST1 (at 0x6e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "SPMI_INT_TEST_VAL"
      sgroup "SPMI_INT_TEST_VAL (at 0x6e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SPMI_INT_TEST_VAL                        = " "0, 1"
    tree.end
    tree "SPMI_TEST1"
      sgroup "SPMI_TEST1 (at 0x6e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x4--0x7 1 "  [ 7: 4]   DTEST_EN                                 = "
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SPMI_DTEST_BYP                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x2 "  [ 2: 0]   DTEST_SEL                                = " "0, 1, 2, 3, 4, 5, 6, 7"
    tree.end
  tree.end
tree.end
tree "SPMI_OPTIONS"
  tree "SPMI_OPTIONS"
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID0"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID0 (at 0x20644)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006440
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6440
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_SLAVE_ID1"
      sgroup "SPMI_OPTIONS_SPMI_SLAVE_ID1 (at 0x20645)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006450
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6450
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_SLAVE_ID1                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID0"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID0 (at 0x20646)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID0                           = "
    tree.end
    tree "SPMI_OPTIONS_SPMI_GROUP_ID1"
      sgroup "SPMI_OPTIONS_SPMI_GROUP_ID1 (at 0x20647)"
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        set &access:&cmd_addr %l 0x8006470
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x2)<<16.)|0x600
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x6470
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   SPMI_GROUP_ID1                           = "
    tree.end
  tree.end
tree.end
tree "TEMP_ALARM"
  tree "TEMP_ALARM"
    tree "TEMP_ALARM_REVISION1"
      sgroup "TEMP_ALARM_REVISION1 (at 0x2400)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION2"
      sgroup "TEMP_ALARM_REVISION2 (at 0x2401)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION3"
      sgroup "TEMP_ALARM_REVISION3 (at 0x2402)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TEMP_ALARM_REVISION4"
      sgroup "TEMP_ALARM_REVISION4 (at 0x2403)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TEMP_ALARM_PERPH_TYPE"
      sgroup "TEMP_ALARM_PERPH_TYPE (at 0x2404)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TEMP_ALARM_PERPH_SUBTYPE"
      sgroup "TEMP_ALARM_PERPH_SUBTYPE (at 0x2405)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TEMP_ALARM_STATUS1"
      sgroup "TEMP_ALARM_STATUS1 (at 0x2408)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_OK                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ST3_SHUTDOWN_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ST2_SHUTDOWN_STS                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_ALARM_FSM_STATE                     = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_INT_RT_STS"
      sgroup "TEMP_ALARM_INT_RT_STS (at 0x2410)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024100
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24100
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_RT_STS                        = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_SET_TYPE"
      sgroup "TEMP_ALARM_INT_SET_TYPE (at 0x2411)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024110
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24110
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_TYPE                          = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_HIGH"
      sgroup "TEMP_ALARM_INT_POLARITY_HIGH (at 0x2412)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024120
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24120
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_HIGH                          = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_POLARITY_LOW"
      sgroup "TEMP_ALARM_INT_POLARITY_LOW (at 0x2413)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024130
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24130
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LOW                           = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_CLR"
      sgroup "TEMP_ALARM_INT_LATCHED_CLR (at 0x2414)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024140
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24140
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_CLR                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_SET"
      sgroup "TEMP_ALARM_INT_EN_SET (at 0x2415)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024150
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24150
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_SET                        = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_EN_CLR"
      sgroup "TEMP_ALARM_INT_EN_CLR (at 0x2416)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024160
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24160
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_EN_CLR                        = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_LATCHED_STS"
      sgroup "TEMP_ALARM_INT_LATCHED_STS (at 0x2418)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024180
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24180
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_LATCHED_STS                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_PENDING_STS"
      sgroup "TEMP_ALARM_INT_PENDING_STS (at 0x2419)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024190
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24190
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_PENDING_STS                   = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_MID_SEL"
      sgroup "TEMP_ALARM_INT_MID_SEL (at 0x241a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   INT_MID_SEL                              = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_INT_PRIORITY"
      sgroup "TEMP_ALARM_INT_PRIORITY (at 0x241b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x80241b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x241b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   INT_PRIORITY                             = " "0, 1"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL1"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL1 (at 0x2440)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024400
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24400
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   OVRD_ST3_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   OVRD_ST2_EN                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TEMP_THRESH_CNTRL                        = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_SHUTDOWN_CTL2"
      sgroup "TEMP_ALARM_SHUTDOWN_CTL2 (at 0x2442)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024420
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24420
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   ST3_SHUTDOWN_CLR                         = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   ST2_SHUTDOWN_CLR                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_EN_CTL1"
      sgroup "TEMP_ALARM_EN_CTL1 (at 0x2446)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024460
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24460
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   TEMP_ALARM_EN                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_TEMP_ALARM_HW_EN                  = " "0, 1"
    tree.end
    tree "TEMP_ALARM_SEC_ACCESS"
      sgroup "TEMP_ALARM_SEC_ACCESS (at 0x24d0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL1"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL1 (at 0x24d8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL2"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL2 (at 0x24d9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024d90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24d90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RB                    = " "0, 1"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL3"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL3 (at 0x24da)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024da0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24da0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TEMP_ALARM_PERPH_RESET_CTL4"
      sgroup "TEMP_ALARM_PERPH_RESET_CTL4 (at 0x24db)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024db0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24db0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_TEST1"
      sgroup "TEMP_ALARM_INT_TEST1 (at 0x24e0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   INT_TEST_MODE_EN                         = " "0, 1"
    tree.end
    tree "TEMP_ALARM_INT_TEST_VAL"
      sgroup "TEMP_ALARM_INT_TEST_VAL (at 0x24e1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEMP_ALARM_STS_TEST_VAL                  = " "0, 1"
    tree.end
    tree "TEMP_ALARM_TEST1"
      sgroup "TEMP_ALARM_TEST1 (at 0x24e2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   DTEST_STAT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   ATEST_BUF_VTEMP                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   ATEST2                                   = " "0, 1, 2, 3"
    tree.end
    tree "TEMP_ALARM_TEST2"
      sgroup "TEMP_ALARM_TEST2 (at 0x24e3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024e30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24e30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   ATEST_VTEMP                              = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   DTEST_STAT                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   ATEST_THRESHOLD                          = " "0, 1"
    tree.end
    tree "TEMP_ALARM_TRIM_NUM"
      sgroup "TEMP_ALARM_TRIM_NUM (at 0x24f0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TRIM_NUM                                 = "
    tree.end
    tree "TEMP_ALARM_TRIM_OFFSET"
      sgroup "TEMP_ALARM_TRIM_OFFSET (at 0x24f1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        set &access:&cmd_addr %l 0x8024f10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0x2400
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0x24f10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x5 1 "  [ 5: 0]   OFFSET                                   = "
    tree.end
  tree.end
tree.end
tree "TRIM"
  tree "TRIM"
    tree "TRIM_REVISION1"
      sgroup "TRIM_REVISION1 (at 0xfe00)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe000
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe000
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MINOR                                = "
    tree.end
    tree "TRIM_REVISION2"
      sgroup "TRIM_REVISION2 (at 0xfe01)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe010
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe010
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   DIG_MAJOR                                = "
    tree.end
    tree "TRIM_REVISION3"
      sgroup "TRIM_REVISION3 (at 0xfe02)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe020
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe020
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MINOR                                = "
    tree.end
    tree "TRIM_REVISION4"
      sgroup "TRIM_REVISION4 (at 0xfe03)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe030
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe030
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   ANA_MAJOR                                = "
    tree.end
    tree "TRIM_PERPH_TYPE"
      sgroup "TRIM_PERPH_TYPE (at 0xfe04)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe040
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe040
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   TYPE                                     = "
    tree.end
    tree "TRIM_PERPH_SUBTYPE"
      sgroup "TRIM_PERPH_SUBTYPE (at 0xfe05)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe050
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe050
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SUBTYPE                                  = "
    tree.end
    tree "TRIM_TRIM_REG_INIT_STATUS"
      sgroup "TRIM_TRIM_REG_INIT_STATUS (at 0xfe08)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe080
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe080
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   TRIM_OTP_NOT_PROG                        = " "0, 1"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   SW_TRIM_REG_INIT_EXEC                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   SW_TRIM_REG_INIT_ON                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   HW_TRIM_REG_INIT_EXEC                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   HW_TRIM_REG_INIT_ON                      = " "0, 1"
    tree.end
    tree "TRIM_OTP_PROG_STATUS"
      sgroup "TRIM_OTP_PROG_STATUS (at 0xfe09)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe090
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe090
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_OTP_ALREADY_PROG                    = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   OTP_PROG_EXEC                            = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TRIM_OTP_PROG_ON                         = " "0, 1"
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_LSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_LSB (at 0xfe0a)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0a0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0a0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_LSB_DATA                          = "
    tree.end
    tree "TRIM_OTP_NUM_TRIM_REG_MSB"
      sgroup "TRIM_OTP_NUM_TRIM_REG_MSB (at 0xfe0b)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fe0b0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfe0b0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   OTP_HA_MSB_DATA                          = "
    tree.end
    tree "TRIM_SEC_ACCESS"
      sgroup "TRIM_SEC_ACCESS (at 0xfed0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x7 1 "  [ 7: 0]   SEC_UNLOCK                               = "
    tree.end
    tree "TRIM_PERPH_RESET_CTL1"
      sgroup "TRIM_PERPH_RESET_CTL1 (at 0xfed8)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed80
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed80
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   ENABLE_PRESET                            = " "0, 1"
    tree.end
    tree "TRIM_PERPH_RESET_CTL2"
      sgroup "TRIM_PERPH_RESET_CTL2 (at 0xfed9)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fed90
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfed90
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_GLOBAL_SOFT_RESET                 = " "0, 1"
    tree.end
    tree "TRIM_PERPH_RESET_CTL3"
      sgroup "TRIM_PERPH_RESET_CTL3 (at 0xfeda)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80feda0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfeda0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   FOLLOW_OTST2_RB                          = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   FOLLOW_WARM_RB                           = " "0, 1"
      textline ""
      bitfld.long 0x0 0x1--0x1 "  [    1]   FOLLOW_SHUTDOWN1_RB                      = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   FOLLOW_SHUTDOWN2_RB                      = " "0, 1"
    tree.end
    tree "TRIM_PERPH_RESET_CTL4"
      sgroup "TRIM_PERPH_RESET_CTL4 (at 0xfedb)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fedb0
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfedb0
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   LOCAL_SOFT_RESET                         = " "0, 1"
    tree.end
    tree "TRIM_TRIM_OTP_CFG1"
      sgroup "TRIM_TRIM_OTP_CFG1 (at 0xfee0)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee00
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee00
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x3--0x3 "  [    3]   TRIM_VPP_SEL                             = " "0, 1"
      textline ""
      bitfld.long 0x0 0x2--0x2 "  [    2]   TRIM_PPROG                               = " "0, 1"
      textline ""
      bitfld.long 0x0 0x0--0x1 "  [ 1: 0]   TRIM_PTM                                 = " "0, 1, 2, 3"
    tree.end
    tree "TRIM_TRIM_OTP_CFG2"
      sgroup "TRIM_TRIM_OTP_CFG2 (at 0xfee1)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee10
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee10
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      hexmask.long.byte 0x0 0x0--0x4 1 "  [ 4: 0]   TRIM_MARGIN_RD_WS                        = "
    tree.end
    tree "TRIM_TRIM_OTP_PROG_CTL"
      sgroup "TRIM_TRIM_OTP_PROG_CTL (at 0xfee2)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee20
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee20
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_OTP_PROG                           = " "0, 1"
    tree.end
    tree "TRIM_TRIM_REG_INIT_CTL"
      sgroup "TRIM_TRIM_REG_INIT_CTL (at 0xfee3)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee30
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee30
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   SW_TRIM_START_COPY                       = " "0, 1"
    tree.end
    tree "TRIM_TRIM_OTP_HA_CTL"
      sgroup "TRIM_TRIM_OTP_HA_CTL (at 0xfee4)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee40
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee40
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   START_GET_OTP_HA                         = " "0, 1"
    tree.end
    tree "TRIM_TEST1"
      sgroup "TRIM_TEST1 (at 0xfee5)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee50
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee50
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x7--0x7 "  [    7]   DTEST4_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x6--0x6 "  [    6]   DTEST3_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x5--0x5 "  [    5]   DTEST2_EN                                = " "0, 1"
      textline ""
      bitfld.long 0x0 0x4--0x4 "  [    4]   DTEST1_EN                                = " "0, 1"
      textline ""
      hexmask.long.byte 0x0 0x0--0x3 1 "  [ 3: 0]   DTEST_SEL                                = "
    tree.end
    tree "TRIM_TEST_TRIM_CLK_REQ"
      sgroup "TRIM_TEST_TRIM_CLK_REQ (at 0xfee6)"
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        set &access:&cmd_addr %l 0x80fee60
        getx &access:&read_addr %l 0
        writeback
        set &access:&chan_addr %l ((&sid+0x0)<<16.)|0xfe00
        setx &access:&write_addr %l 0
        set &access:&cmd_addr %l 0xfee60
      line.byte 0x0 "VALUE"
      textline "BITS"
      textline ""
      bitfld.long 0x0 0x0--0x0 "  [    0]   TEST_CLK_REQ                             = " "0, 1"
    tree.end
  tree.end
tree.end

